Properties of the parts of a building model (IFC2X3), part 3 of 4

# IfcReinforcingBar (1147)
Name | NominalDiameter (mm) = K-M03 Diameter | Material = K-M02 Kvalitet | K-M00 Pos. | K-M01 Antall | K-M04 Korrigert lengde min. | K-M06 Total lengde (m) | K-M07 Vekt pr. stk./Vekt pr. stk. min.(kg) | K-M08 Total vekt (kg) | K-M09 Form | K-M12 A/A min. | K-M29 Plassering | K-M30 Senteravstand | K-M32 BVBS enkeltjern | A04 Status MMI | A05 Link til notater | A06 Link til beskrivelser | A07 Link til tegninger | A09 Revisjonsdato | A10 Revisjonsmerknad | A00 Objektnavn = A01 Objektkode V440 = A02 Objektkode V770 = A03 Spesiell beskrivelse | A08 Revisjon | K-M28 Armeringslag | K-M31 Konstruksjonsdel
2 x Løpemeter | 20 | B500NC | Lm3145 | 1 | 3110 | 3110 | 7.7 | 7.7 | 00 | 3110 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3145@l3115@n1@e7.67@d20@gB500NC@s0@a0@t0@Gl3115@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3143 | 1 | 3115 | 3115 | 7.7 | 7.7 | 00 | 3115 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3143@l3115@n1@e7.68@d20@gB500NC@s0@a0@t0@Gl3115@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
3 x Løpemeter | 20 | B500NC | Lm3143 | 1 | 3120 | 3120 | 7.7 | 7.7 | 00 | 3120 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3143@l3115@n1@e7.68@d20@gB500NC@s0@a0@t0@Gl3115@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3142 | 1 | 5985 | 5985 | 14.8 | 14.8 | 00 | 5985 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3142@l5985@n1@e14.76@d20@gB500NC@s0@a0@t0@Gl5985@w0@C89@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3142 | 1 | 5980 | 5980 | 14.7 | 14.7 | 00 | 5980 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3142@l5985@n1@e14.76@d20@gB500NC@s0@a0@t0@Gl5985@w0@C89@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3141 | 9 | 6530 | 58770 | 16.1 | 145 | 00 | 6530 | Lag 2 | 8*200 | BF2D@Hj10259741-01@rMC@i01@pLm3141@l6530@n1@e16.1@d20@gB500NC@s0@a0@t0@Gl6530@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3140 | 1 | 6265 | 6265 | 15.4 | 15.4 | 00 | 6265 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3140@l6265@n1@e15.45@d20@gB500NC@s0@a0@t0@Gl6265@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3139 | 1 | 5680 | 5680 | 14 | 14 | 00 | 5680 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3139@l5680@n1@e14.01@d20@gB500NC@s0@a0@t0@Gl5680@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3138 | 1 | 5175 | 5175 | 12.8 | 12.8 | 00 | 5175 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3138@l5175@n1@e12.76@d20@gB500NC@s0@a0@t0@Gl5175@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3137 | 1 | 4985 | 4985 | 12.3 | 12.3 | 00 | 4985 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3137@l4985@n1@e12.29@d20@gB500NC@s0@a0@t0@Gl4985@w0@C91@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3136 | 1 | 4035 | 4035 | 10 | 10 | 00 | 4035 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3136@l4035@n1@e9.95@d20@gB500NC@s0@a0@t0@Gl4035@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3135 | 1 | 3940 | 3940 | 9.7 | 9.7 | 00 | 3940 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3135@l3940@n1@e9.72@d20@gB500NC@s0@a0@t0@Gl3940@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3134 | 1 | 3850 | 3850 | 9.5 | 9.5 | 00 | 3850 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3134@l3850@n1@e9.49@d20@gB500NC@s0@a0@t0@Gl3850@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3144 | 10 | 3615 | 36150 | 8.9 | 89.1 | 00 | 3615 | Lag 1 | 9*200 | BF2D@Hj10259741-01@rMC@i01@pLm3144@l3615@n1@e8.92@d20@gB500NC@s0@a0@t0@Gl3615@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3001 | 1 | 750 | 750 | 1.8 | 1.8 | 00 | 750 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3001@l750@n1@e1.85@d20@gB500NC@s0@a0@t0@Gl750@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3083 | 3 | 3130 | 9390 | 7.7 | 23.2 | 00 | 3130 | Lag 1 | 2*200 | BF2D@Hj10259741-01@rMC@i01@pLm3083@l3130@n1@e7.72@d20@gB500NC@s0@a0@t0@Gl3130@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3070 | 1 | 3065 | 3065 | 7.6 | 7.6 | 00 | 3065 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3070@l3065@n1@e7.56@d20@gB500NC@s0@a0@t0@Gl3065@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3077 | 1 | 3095 | 3095 | 7.6 | 7.6 | 00 | 3095 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3077@l3095@n1@e7.63@d20@gB500NC@s0@a0@t0@Gl3095@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3069 | 1 | 3060 | 3060 | 7.5 | 7.5 | 00 | 3060 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3069@l3060@n1@e7.55@d20@gB500NC@s0@a0@t0@Gl3060@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3068 | 1 | 3060 | 3060 | 7.5 | 7.5 | 00 | 3060 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3068@l3060@n1@e7.55@d20@gB500NC@s0@a0@t0@Gl3060@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3067 | 1 | 3055 | 3055 | 7.5 | 7.5 | 00 | 3055 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3067@l3055@n1@e7.53@d20@gB500NC@s0@a0@t0@Gl3055@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3066 | 1 | 3050 | 3050 | 7.5 | 7.5 | 00 | 3050 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3066@l3050@n1@e7.52@d20@gB500NC@s0@a0@t0@Gl3050@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3065 | 1 | 3045 | 3045 | 7.5 | 7.5 | 00 | 3045 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3065@l3045@n1@e7.51@d20@gB500NC@s0@a0@t0@Gl3045@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3065 | 1 | 3040 | 3040 | 7.5 | 7.5 | 00 | 3040 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3065@l3045@n1@e7.51@d20@gB500NC@s0@a0@t0@Gl3045@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3093 | 1 | 3035 | 3035 | 7.5 | 7.5 | 00 | 3035 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3093@l825@n1@e2.03@d20@gB500NC@s0@a0@t0@Gl825@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3015 | 1 | 3025 | 3025 | 7.5 | 7.5 | 00 | 3025 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3015@l495@n1@e1.22@d20@gB500NC@s0@a0@t0@Gl495@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3092 | 1 | 2990 | 2990 | 7.4 | 7.4 | 00 | 2990 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3092@l805@n1@e1.99@d20@gB500NC@s0@a0@t0@Gl805@w0@C96@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3091 | 1 | 3005 | 3005 | 7.4 | 7.4 | 00 | 3005 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3091@l715@n1@e1.76@d20@gB500NC@s0@a0@t0@Gl715@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3147 | 3 | 3020 | 9060 | 7.4 | 22.4 | 00 | 3020 | Lag 1 | 2*200 | BF2D@Hj10259741-01@rMC@i01@pLm3147@l3020@n1@e7.45@d20@gB500NC@s0@a0@t0@Gl3020@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3015 | 3 | 3025 | 9075 | 7.5 | 22.4 | 00 | 3025 | Lag 1 | 2*200 | BF2D@Hj10259741-01@rMC@i01@pLm3015@l495@n1@e1.22@d20@gB500NC@s0@a0@t0@Gl495@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3090 | 1 | 2910 | 2910 | 7.2 | 7.2 | 00 | 2910 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3090@l595@n1@e1.47@d20@gB500NC@s0@a0@t0@Gl595@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3132 | 1 | 2850 | 2850 | 7 | 7 | 00 | 2850 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3132@l3035@n1@e7.48@d20@gB500NC@s0@a0@t0@Gl3035@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3089 | 1 | 2790 | 2790 | 6.9 | 6.9 | 00 | 2790 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3089@l480@n1@e1.18@d20@gB500NC@s0@a0@t0@Gl480@w0@C69@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3088 | 1 | 2730 | 2730 | 6.7 | 6.7 | 00 | 2730 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3088@l13895@n1@e34.27@d20@gB500NC@s0@a0@t0@Gl13895@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3131 | 1 | 2675 | 2675 | 6.6 | 6.6 | 00 | 2675 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3131@l2990@n1@e7.37@d20@gB500NC@s0@a0@t0@Gl2990@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3130 | 1 | 2615 | 2615 | 6.4 | 6.4 | 00 | 2615 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3130@l3005@n1@e7.41@d20@gB500NC@s0@a0@t0@Gl3005@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3084 | 1 | 2555 | 2555 | 6.3 | 6.3 | 00 | 2555 | Lag 1 |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3149 | 1 | 2980 | 2980 | 7.3 | 7.3 | 00 | 2980 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3149@l2975@n1@e7.34@d20@gB500NC@s0@a0@t0@Gl2975@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3081 | 1 | 2495 | 2495 | 6.2 | 6.2 | 00 | 2495 | Lag 1 |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3119 | 1 | 2435 | 2435 | 6 | 6 | 00 | 2435 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3119@l2430@n1@e5.99@d20@gB500NC@s0@a0@t0@Gl2430@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3126 | 1 | 2375 | 2375 | 5.9 | 5.9 | 00 | 2375 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3126@l2850@n1@e7.03@d20@gB500NC@s0@a0@t0@Gl2850@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3125 | 1 | 2315 | 2315 | 5.7 | 5.7 | 00 | 2315 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3125@l2790@n1@e6.88@d20@gB500NC@s0@a0@t0@Gl2790@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3124 | 1 | 2255 | 2255 | 5.6 | 5.6 | 00 | 2255 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3124@l2735@n1@e6.73@d20@gB500NC@s0@a0@t0@Gl2735@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3123 | 1 | 2195 | 2195 | 5.4 | 5.4 | 00 | 2195 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3123@l2675@n1@e6.6@d20@gB500NC@s0@a0@t0@Gl2675@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3122 | 1 | 2130 | 2130 | 5.3 | 5.3 | 00 | 2130 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3122@l2615@n1@e6.45@d20@gB500NC@s0@a0@t0@Gl2615@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3121 | 1 | 2065 | 2065 | 5.1 | 5.1 | 00 | 2065 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3121@l2555@n1@e6.3@d20@gB500NC@s0@a0@t0@Gl2555@w0@C89@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3120 | 1 | 2000 | 2000 | 4.9 | 4.9 | 00 | 2000 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3120@l2495@n1@e6.15@d20@gB500NC@s0@a0@t0@Gl2495@w0@C65@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3039 | 1 | 1935 | 1935 | 4.8 | 4.8 | 00 | 1935 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3039@l1965@n1@e4.85@d20@gB500NC@s0@a0@t0@Gl1965@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3043 | 1 | 1945 | 1945 | 4.8 | 4.8 | 00 | 1945 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3043@l2070@n1@e5.11@d20@gB500NC@s0@a0@t0@Gl2070@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3042 | 1 | 1955 | 1955 | 4.8 | 4.8 | 00 | 1955 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3042@l2005@n1@e4.94@d20@gB500NC@s0@a0@t0@Gl2005@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3041 | 1 | 1965 | 1965 | 4.8 | 4.8 | 00 | 1965 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3041@l1945@n1@e4.8@d20@gB500NC@s0@a0@t0@Gl1945@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3115 | 1 | 1930 | 1930 | 4.8 | 4.8 | 00 | 1930 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3115@l2195@n1@e5.41@d20@gB500NC@s0@a0@t0@Gl2195@w0@C69@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3114 | 1 | 1865 | 1865 | 4.6 | 4.6 | 00 | 1865 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3114@l2130@n1@e5.25@d20@gB500NC@s0@a0@t0@Gl2130@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3087 | 1 | 9055 | 9055 | 22.3 | 22.3 | 00 | 9055 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3087@l9055@n1@e22.33@d20@gB500NC@s0@a0@t0@Gl9055@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3113 | 1 | 1795 | 1795 | 4.4 | 4.4 | 00 | 1795 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3113@l2065@n1@e5.09@d20@gB500NC@s0@a0@t0@Gl2065@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3112 | 1 | 1730 | 1730 | 4.3 | 4.3 | 00 | 1730 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3112@l2000@n1@e4.93@d20@gB500NC@s0@a0@t0@Gl2000@w0@C96@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3080 | 1 | 1665 | 1665 | 4.1 | 4.1 | 00 | 1665 | Lag 1 |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3062 | 1 | 1600 | 1600 | 3.9 | 3.9 | 00 | 1600 | Lag 1 |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3056 | 1 | 1535 | 1535 | 3.8 | 3.8 | 00 | 1535 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3056@l2860@n1@e7.05@d20@gB500NC@s0@a0@t0@Gl2860@w0@C65@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3048 | 1 | 1465 | 1465 | 3.6 | 3.6 | 00 | 1465 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3048@l2380@n1@e5.87@d20@gB500NC@s0@a0@t0@Gl2380@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3111 | 1 | 1400 | 1400 | 3.5 | 3.5 | 00 | 1400 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3111@l1930@n1@e4.76@d20@gB500NC@s0@a0@t0@Gl1930@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3110 | 1 | 1335 | 1335 | 3.3 | 3.3 | 00 | 1335 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3110@l1865@n1@e4.6@d20@gB500NC@s0@a0@t0@Gl1865@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3098 | 1 | 1270 | 1270 | 3.1 | 3.1 | 00 | 1270 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3098@l1000@n1@e2.47@d20@gB500NC@s0@a0@t0@Gl1000@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3099 | 1 | 1190 | 1190 | 2.9 | 2.9 | 00 | 1190 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3099@l1095@n1@e2.7@d20@gB500NC@s0@a0@t0@Gl1095@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3107 | 1 | 1095 | 1095 | 2.7 | 2.7 | 00 | 1095 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3107@l1665@n1@e4.11@d20@gB500NC@s0@a0@t0@Gl1665@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3106 | 1 | 1000 | 1000 | 2.5 | 2.5 | 00 | 1000 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3106@l1600@n1@e3.95@d20@gB500NC@s0@a0@t0@Gl1600@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3105 | 1 | 905 | 905 | 2.2 | 2.2 | 00 | 905 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3105@l1535@n1@e3.79@d20@gB500NC@s0@a0@t0@Gl1535@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3104 | 1 | 925 | 925 | 2.3 | 2.3 | 00 | 925 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3104@l1465@n1@e3.61@d20@gB500NC@s0@a0@t0@Gl1465@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3103 | 1 | 955 | 955 | 2.4 | 2.4 | 00 | 955 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3103@l1400@n1@e3.45@d20@gB500NC@s0@a0@t0@Gl1400@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3102 | 1 | 985 | 985 | 2.4 | 2.4 | 00 | 985 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3102@l1335@n1@e3.29@d20@gB500NC@s0@a0@t0@Gl1335@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3101 | 1 | 1015 | 1015 | 2.5 | 2.5 | 00 | 1015 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3101@l1270@n1@e3.13@d20@gB500NC@s0@a0@t0@Gl1270@w0@C91@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3100 | 1 | 1040 | 1040 | 2.6 | 2.6 | 00 | 1040 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3100@l1195@n1@e2.94@d20@gB500NC@s0@a0@t0@Gl1195@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3099 | 1 | 1195 | 1195 | 2.9 | 2.9 | 00 | 1195 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3099@l1095@n1@e2.7@d20@gB500NC@s0@a0@t0@Gl1095@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3096 | 1 | 1110 | 1110 | 2.7 | 2.7 | 00 | 1110 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3096@l880@n1@e2.17@d20@gB500NC@s0@a0@t0@Gl880@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3029 | 1 | 1270 | 1270 | 3.1 | 3.1 | 00 | 1270 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3029@l1405@n1@e3.47@d20@gB500NC@s0@a0@t0@Gl1405@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3029 | 1 | 1275 | 1275 | 3.1 | 3.1 | 00 | 1275 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3029@l1405@n1@e3.47@d20@gB500NC@s0@a0@t0@Gl1405@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3014 | 1 | 1275 | 1275 | 3.1 | 3.1 | 00 | 1275 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3014@l490@n1@e1.21@d20@gB500NC@s0@a0@t0@Gl490@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3028 | 5 | 15910 | 79550 | 39.2 | 196.2 | 00 | 15910 | Lag 1 | 4*200 | BF2D@Hj10259741-01@rMC@i01@pLm3028@l1340@n1@e3.3@d20@gB500NC@s0@a0@t0@Gl1340@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3013 | 1 | 795 | 795 | 2 | 2 | 00 | 795 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3013@l15910@n1@e39.23@d20@gB500NC@s0@a0@t0@Gl15910@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3028 | 5 | 15910 | 79550 | 39.2 | 196.2 | 00 | 15910 | Lag 2 | 4*200 | BF2D@Hj10259741-01@rMC@i01@pLm3028@l1340@n1@e3.3@d20@gB500NC@s0@a0@t0@Gl1340@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3010 | 1 | 13385 | 13385 | 33 | 33 | 00 | 13385 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3010@l13385@n1@e33.01@d20@gB500NC@s0@a0@t0@Gl13385@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3009 | 1 | 12910 | 12910 | 31.8 | 31.8 | 00 | 12910 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3009@l12910@n1@e31.84@d20@gB500NC@s0@a0@t0@Gl12910@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3008 | 1 | 12305 | 12305 | 30.3 | 30.3 | 00 | 12305 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3008@l12305@n1@e30.34@d20@gB500NC@s0@a0@t0@Gl12305@w0@C96@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3007 | 1 | 11700 | 11700 | 28.9 | 28.9 | 00 | 11700 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3007@l11700@n1@e28.85@d20@gB500NC@s0@a0@t0@Gl11700@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3006 | 1 | 11095 | 11095 | 27.4 | 27.4 | 00 | 11095 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3006@l11095@n1@e27.36@d20@gB500NC@s0@a0@t0@Gl11095@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3005 | 1 | 9695 | 9695 | 23.9 | 23.9 | 00 | 9695 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3005@l9695@n1@e23.91@d20@gB500NC@s0@a0@t0@Gl9695@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3004 | 1 | 8385 | 8385 | 20.7 | 20.7 | 00 | 8385 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3004@l8385@n1@e20.68@d20@gB500NC@s0@a0@t0@Gl8385@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3003 | 1 | 7715 | 7715 | 19 | 19 | 00 | 7715 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3003@l7715@n1@e19.03@d20@gB500NC@s0@a0@t0@Gl7715@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3002 | 1 | 7045 | 7045 | 17.4 | 17.4 | 00 | 7045 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3002@l7045@n1@e17.37@d20@gB500NC@s0@a0@t0@Gl7045@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3086 | 1 | 2570 | 2570 | 6.3 | 6.3 | 00 | 2570 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3086@l2570@n1@e6.34@d20@gB500NC@s0@a0@t0@Gl2570@w0@C65@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3085 | 1 | 3585 | 3585 | 8.8 | 8.8 | 00 | 3585 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3085@l3585@n1@e8.84@d20@gB500NC@s0@a0@t0@Gl3585@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3144 | 1 | 3610 | 3610 | 8.9 | 8.9 | 00 | 3610 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3144@l3615@n1@e8.92@d20@gB500NC@s0@a0@t0@Gl3615@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3083 | 1 | 3130 | 3130 | 7.7 | 7.7 | 00 | 3130 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3083@l3130@n1@e7.72@d20@gB500NC@s0@a0@t0@Gl3130@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3082 | 1 | 3125 | 3125 | 7.7 | 7.7 | 00 | 3125 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3082@l3125@n1@e7.71@d20@gB500NC@s0@a0@t0@Gl3125@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3145 | 1 | 3115 | 3115 | 7.7 | 7.7 | 00 | 3115 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3145@l3115@n1@e7.67@d20@gB500NC@s0@a0@t0@Gl3115@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3079 | 1 | 3110 | 3110 | 7.7 | 7.7 | 00 | 3110 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3079@l3105@n1@e7.66@d20@gB500NC@s0@a0@t0@Gl3105@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3078 | 1 | 3100 | 3100 | 7.6 | 7.6 | 00 | 3100 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3078@l3100@n1@e7.65@d20@gB500NC@s0@a0@t0@Gl3100@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3076 | 1 | 3090 | 3090 | 7.6 | 7.6 | 00 | 3090 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3076@l3090@n1@e7.62@d20@gB500NC@s0@a0@t0@Gl3090@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3075 | 1 | 3085 | 3085 | 7.6 | 7.6 | 00 | 3085 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3075@l3090@n1@e7.62@d20@gB500NC@s0@a0@t0@Gl3090@w0@C69@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3074 | 1 | 3080 | 3080 | 7.6 | 7.6 | 00 | 3080 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3074@l3085@n1@e7.61@d20@gB500NC@s0@a0@t0@Gl3085@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3073 | 1 | 3075 | 3075 | 7.6 | 7.6 | 00 | 3075 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3073@l3080@n1@e7.6@d20@gB500NC@s0@a0@t0@Gl3080@w0@C91@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3068 | 1 | 3055 | 3055 | 7.5 | 7.5 | 00 | 3055 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3068@l3060@n1@e7.55@d20@gB500NC@s0@a0@t0@Gl3060@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3067 | 1 | 3050 | 3050 | 7.5 | 7.5 | 00 | 3050 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3067@l3055@n1@e7.53@d20@gB500NC@s0@a0@t0@Gl3055@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3066 | 1 | 3045 | 3045 | 7.5 | 7.5 | 00 | 3045 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3066@l3050@n1@e7.52@d20@gB500NC@s0@a0@t0@Gl3050@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3064 | 1 | 3030 | 3030 | 7.5 | 7.5 | 00 | 3030 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3064@l3030@n1@e7.47@d20@gB500NC@s0@a0@t0@Gl3030@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3063 | 1 | 2980 | 2980 | 7.3 | 7.3 | 00 | 2980 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3063@l2985@n1@e7.35@d20@gB500NC@s0@a0@t0@Gl2985@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3061 | 1 | 3010 | 3010 | 7.4 | 7.4 | 00 | 3010 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3061@l3005@n1@e7.41@d20@gB500NC@s0@a0@t0@Gl3005@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3060 | 1 | 2920 | 2920 | 7.2 | 7.2 | 00 | 2920 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3060@l3025@n1@e7.46@d20@gB500NC@s0@a0@t0@Gl3025@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3059 | 1 | 3555 | 3555 | 8.8 | 8.8 | 00 | 3555 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3059@l3555@n1@e8.77@d20@gB500NC@s0@a0@t0@Gl3555@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3058 | 1 | 2860 | 2860 | 7.1 | 7.1 | 00 | 2860 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3058@l2980@n1@e7.35@d20@gB500NC@s0@a0@t0@Gl2980@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3057 | 1 | 2800 | 2800 | 6.9 | 6.9 | 00 | 2800 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3057@l2920@n1@e7.2@d20@gB500NC@s0@a0@t0@Gl2920@w0@C89@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3055 | 1 | 2680 | 2680 | 6.6 | 6.6 | 00 | 2680 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3055@l2800@n1@e6.91@d20@gB500NC@s0@a0@t0@Gl2800@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3012 | 1 | 2620 | 2620 | 6.5 | 6.5 | 00 | 2620 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3012@l15345@n1@e37.84@d20@gB500NC@s0@a0@t0@Gl15345@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3053 | 1 | 2560 | 2560 | 6.3 | 6.3 | 00 | 2560 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3053@l2680@n1@e6.61@d20@gB500NC@s0@a0@t0@Gl2680@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3052 | 1 | 2500 | 2500 | 6.2 | 6.2 | 00 | 2500 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3052@l2620@n1@e6.46@d20@gB500NC@s0@a0@t0@Gl2620@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3051 | 1 | 2440 | 2440 | 6 | 6 | 00 | 2440 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3051@l2560@n1@e6.31@d20@gB500NC@s0@a0@t0@Gl2560@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3050 | 1 | 2380 | 2380 | 5.9 | 5.9 | 00 | 2380 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3050@l2500@n1@e6.17@d20@gB500NC@s0@a0@t0@Gl2500@w0@C87@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3049 | 1 | 2320 | 2320 | 5.7 | 5.7 | 00 | 2320 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3049@l2440@n1@e6.02@d20@gB500NC@s0@a0@t0@Gl2440@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3158 | 1 | 2260 | 2260 | 5.6 | 5.6 | 00 | 2260 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3158@l2265@n1@e5.59@d20@gB500NC@s0@a0@t0@Gl2265@w0@C89@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3047 | 1 | 2200 | 2200 | 5.4 | 5.4 | 00 | 2200 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3047@l2320@n1@e5.72@d20@gB500NC@s0@a0@t0@Gl2320@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3011 | 1 | 2135 | 2135 | 5.3 | 5.3 | 00 | 2135 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3011@l15015@n1@e37.03@d20@gB500NC@s0@a0@t0@Gl15015@w0@C65@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3045 | 1 | 2070 | 2070 | 5.1 | 5.1 | 00 | 2070 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3045@l2200@n1@e5.43@d20@gB500NC@s0@a0@t0@Gl2200@w0@C91@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3044 | 1 | 2005 | 2005 | 4.9 | 4.9 | 00 | 2005 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3044@l2135@n1@e5.27@d20@gB500NC@s0@a0@t0@Gl2135@w0@C76@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3040 | 1 | 1975 | 1975 | 4.9 | 4.9 | 00 | 1975 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3040@l1955@n1@e4.82@d20@gB500NC@s0@a0@t0@Gl1955@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3038 | 1 | 1870 | 1870 | 4.6 | 4.6 | 00 | 1870 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3038@l1975@n1@e4.87@d20@gB500NC@s0@a0@t0@Gl1975@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3037 | 1 | 1805 | 1805 | 4.5 | 4.5 | 00 | 1805 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3037@l1935@n1@e4.77@d20@gB500NC@s0@a0@t0@Gl1935@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3036 | 1 | 1740 | 1740 | 4.3 | 4.3 | 00 | 1740 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3036@l1870@n1@e4.61@d20@gB500NC@s0@a0@t0@Gl1870@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3035 | 1 | 1670 | 1670 | 4.1 | 4.1 | 00 | 1670 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3035@l1805@n1@e4.45@d20@gB500NC@s0@a0@t0@Gl1805@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3034 | 1 | 1605 | 1605 | 4 | 4 | 00 | 1605 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3034@l1740@n1@e4.29@d20@gB500NC@s0@a0@t0@Gl1740@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3033 | 1 | 1540 | 1540 | 3.8 | 3.8 | 00 | 1540 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3033@l1670@n1@e4.12@d20@gB500NC@s0@a0@t0@Gl1670@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3032 | 1 | 1475 | 1475 | 3.6 | 3.6 | 00 | 1475 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3032@l1605@n1@e3.96@d20@gB500NC@s0@a0@t0@Gl1605@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3031 | 1 | 1405 | 1405 | 3.5 | 3.5 | 00 | 1405 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3031@l1540@n1@e3.8@d20@gB500NC@s0@a0@t0@Gl1540@w0@C69@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3030 | 1 | 1340 | 1340 | 3.3 | 3.3 | 00 | 1340 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3030@l1475@n1@e3.64@d20@gB500NC@s0@a0@t0@Gl1475@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3018 | 1 | 1200 | 1200 | 3 | 3 | 00 | 1200 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3018@l815@n1@e2.01@d20@gB500NC@s0@a0@t0@Gl815@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3027 | 1 | 1105 | 1105 | 2.7 | 2.7 | 00 | 1105 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3027@l1275@n1@e3.14@d20@gB500NC@s0@a0@t0@Gl1275@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3026 | 1 | 1005 | 1005 | 2.5 | 2.5 | 00 | 1005 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3026@l1200@n1@e2.96@d20@gB500NC@s0@a0@t0@Gl1200@w0@C89@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3025 | 1 | 910 | 910 | 2.2 | 2.2 | 00 | 910 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3025@l1105@n1@e2.73@d20@gB500NC@s0@a0@t0@Gl1105@w0@C87@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3024 | 1 | 935 | 935 | 2.3 | 2.3 | 00 | 935 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3024@l1005@n1@e2.48@d20@gB500NC@s0@a0@t0@Gl1005@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3023 | 1 | 965 | 965 | 2.4 | 2.4 | 00 | 965 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3023@l910@n1@e2.24@d20@gB500NC@s0@a0@t0@Gl910@w0@C87@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3022 | 1 | 990 | 990 | 2.4 | 2.4 | 00 | 990 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3022@l890@n1@e2.2@d20@gB500NC@s0@a0@t0@Gl890@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
