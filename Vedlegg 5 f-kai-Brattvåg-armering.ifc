Properties of the parts of a building model (IFC2X3), part 4 of 4

# IfcReinforcingBar (1147)
Name | NominalDiameter (mm) = K-M03 Diameter | Material = K-M02 Kvalitet | K-M00 Pos. | K-M01 Antall | K-M04 Korrigert lengde min. | K-M06 Total lengde (m) | K-M07 Vekt pr. stk./Vekt pr. stk. min.(kg) | K-M08 Total vekt (kg) | K-M09 Form | K-M12 A/A min. | K-M29 Plassering | K-M30 Senteravstand | K-M32 BVBS enkeltjern | A04 Status MMI | A05 Link til notater | A06 Link til beskrivelser | A07 Link til tegninger | A09 Revisjonsdato | A10 Revisjonsmerknad | A00 Objektnavn = A01 Objektkode V440 = A02 Objektkode V770 = A03 Spesiell beskrivelse | A08 Revisjon | K-M28 Armeringslag | K-M31 Konstruksjonsdel
Løpemeter | 20 | B500NC | Lm3021 | 1 | 1020 | 1020 | 2.5 | 2.5 | 00 | 1020 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3021@l870@n1@e2.15@d20@gB500NC@s0@a0@t0@Gl870@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3020 | 1 | 1050 | 1050 | 2.6 | 2.6 | 00 | 1050 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3020@l850@n1@e2.1@d20@gB500NC@s0@a0@t0@Gl850@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3019 | 1 | 1115 | 1115 | 2.7 | 2.7 | 00 | 1115 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3019@l835@n1@e2.06@d20@gB500NC@s0@a0@t0@Gl835@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3018 | 1 | 1205 | 1205 | 3 | 3 | 00 | 1205 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3018@l815@n1@e2.01@d20@gB500NC@s0@a0@t0@Gl815@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3017 | 1 | 3525 | 3525 | 8.7 | 8.7 | 00 | 3525 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3017@l725@n1@e1.79@d20@gB500NC@s0@a0@t0@Gl725@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3016 | 1 | 3550 | 3550 | 8.8 | 8.8 | 00 | 3550 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3016@l600@n1@e1.48@d20@gB500NC@s0@a0@t0@Gl600@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3014 | 1 | 1280 | 1280 | 3.2 | 3.2 | 00 | 1280 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3014@l490@n1@e1.21@d20@gB500NC@s0@a0@t0@Gl490@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3000 | 1 | 735 | 735 | 1.8 | 1.8 | 00 | 735 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3000@l735@n1@e1.81@d20@gB500NC@s0@a0@t0@Gl735@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
ARMERING | 16 | B500NC | P6007 | 7 | 5700 | 39900 | 9 | 63 | 00 | 5700 | SK | 1*45 + 5*150 | BF2D@Hj10259741-01@rMC@i01@pP6007@l5700@n1@e9@d16@gB500NC@s0@a0@t0@Gl5700@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Fundament
ARMERING | 16 | B500NC | P6007 | 7 | 5700 | 39900 | 9 | 63 | 00 | 5700 | SK | 5*150 + 1*45 | BF2D@Hj10259741-01@rMC@i01@pP6007@l5700@n1@e9@d16@gB500NC@s0@a0@t0@Gl5700@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Fundament
ARMERING | 16 | B500NC | P6007 | 4 | 5700 | 22800 | 9 | 36 | 00 | 5700 | UK | 2*200 + 1*125 | BF2D@Hj10259741-01@rMC@i01@pP6007@l5700@n1@e9@d16@gB500NC@s0@a0@t0@Gl5700@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Fundament
2 x ARMERING | 16 | B500NC | P6004 | 1 | 3880 | 3880 | 6.1 | 6.1 | 21 | 1800 | UK |  | BF2D@Hj10259741-01@rMC@i01@pP6004@l3750@n1@e5.92@d16@gB500NC@s50@a0@t0@Gl1800@w90@l220@w90@l1800@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 350; K-M16 C/C min.: 1800
2 x ARMERING | 16 | B500NC | P6008 | 1 | 4075 | 4075 | 6.4 | 6.4 | 21 | 1800 | UK |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 545; K-M16 C/C min.: 1800
ARMERING | 16 | B500NC | P6006 | 39 | 2515 | 98085 | 4 | 154.8 | 21 | 1000 | SK | 37*150 + 1*110 | BF2D@Hj10259741-01@rMC@i01@pP6006@l8340@n1@e13.16@d16@gB500NC@s50@a0@t0@Gl1300@w90@l5810@w90@l1300@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 585; K-M16 C/C min.: 1000
ARMERING | 16 | B500NC | P6005 | 19 | 2320 | 44080 | 3.7 | 69.7 | 21 | 1000 | SK | 17*150 + 1*130 | BF2D@Hj10259741-01@rMC@i01@pP6005@l2190@n1@e3.46@d16@gB500NC@s50@a0@t0@Gl1000@w90@l260@w90@l1000@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 390; K-M16 C/C min.: 1000
ARMERING | 16 | B500NC | P6003 | 7 | 6290 | 44030 | 9.9 | 69.5 | 21 | 1800 | SK | 5*150 + 1*85 | BF2D@Hj10259741-01@rMC@i01@pP6003@l6290@n1@e9.93@d16@gB500NC@s50@a0@t0@Gl1800@w90@l2760@w90@l1800@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 2760; K-M16 C/C min.: 1800
ARMERING | 16 | B500NC | P6003 | 7 | 6290 | 44030 | 9.9 | 69.5 | 21 | 1800 | SK | 5*150 + 1*45 | BF2D@Hj10259741-01@rMC@i01@pP6003@l6290@n1@e9.93@d16@gB500NC@s50@a0@t0@Gl1800@w90@l2760@w90@l1800@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 2760; K-M16 C/C min.: 1800
ARMERING | 16 | B500NC | P6028 | 20 | 4740 | 94800 | 7.5 | 149.6 | 21 | 1000 | OK | 18*150 + 1*40 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 2810; K-M16 C/C min.: 1000
ARMERING | 16 | B500NC | P6002 | 19 | 5340 | 101460 | 8.4 | 160.1 | 21 | 1300 | OK | 18*150 | BF2D@Hj10259741-01@rMC@i01@pP6002@l5340@n1@e8.43@d16@gB500NC@s50@a0@t0@Gl1300@w90@l2810@w90@l1300@w0@C92@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 2810; K-M16 C/C min.: 1300
ARMERING | 20 | B500NC | P3011 | 16 | 2310 | 36960 | 5.7 | 91.3 | 21 | 1000 | SK | 15*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3175 | 20 | 820 | 81900 | 2 | 197 | 00 | 820 | Lag 1 | 18*200 + 1*71 | Variable groupC77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Tilpasses bergoverflate; K-M05 Korrigert lengde max.: 7370; K-M13 A max.: 7370
Løpemeter | 20 | B500NC | Lm3174 | 20 | 820 | 81900 | 2 | 197 | 00 | 820 | Lag 1 | 1*71 + 18*200 | Variable groupC77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Tilpasses bergoverflate; K-M05 Korrigert lengde max.: 7370; K-M13 A max.: 7370
ARMERING | 20 | B500NC | P5055 | 3 | 5310 | 15930 | 13.1 | 39.3 | 21 | 2500 | YK | 2*200 | BF2D@Hj10259741-01@rMC@i01@pP5055@l5315@n1@e13.09@d20@gB500NC@s80@a0@t0@Gl2500@w90@l410@w90@l2500@w0@C87@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 2500
ARMERING | 16 | B500NC | P5026 | 4 | 7190 | 28760 | 11.3 | 45.4 | 00 | 7190 | OK | 1*100 + 1*70 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5026@l7190@n1@e11.35@d16@gB500NC@s0@a0@t0@Gl7190@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 20 | B500NC | P3013 | 32 | 3260 | 104320 | 8 | 257.6 | 21 | 1500 | OK | 1*32 + 30*200 | BF2D@Hj10259741-01@rMC@i01@pP3013@l3265@n1@e8.04@d20@gB500NC@s80@a0@t0@Gl1500@w90@l360@w90@l1500@w0@C76@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1500
ARMERING | 20 | B500NC | P3010 | 34 | 2260 | 76840 | 5.6 | 189.9 | 21 | 1000 | UK | 1*126 + 32*200 | BF2D@Hj10259741-01@rMC@i01@pP3010@l2265@n1@e5.57@d20@gB500NC@s80@a0@t0@Gl1000@w90@l360@w90@l1000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3005 | 7 | 2575 | 18025 | 6.3 | 44.5 | 99 |  | Lag 2 | 1*205 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP3005@l2575@n1@e6.35@d20@gB500NC@s50@a0@t0@Gl1000@w90@l660@w90@l1000@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3173 | 29 | 565 | 63872.5 | 1.4 | 157.9 | 00 | 565 | Lag 2 | 1*216 + 27*200 | Variable groupC77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Tilpasses bergoverflate; K-M05 Korrigert lengde max.: 3840; K-M13 A max.: 3840
Løpemeter | 20 | B500NC | Lm3172 | 29 | 565 | 63872.5 | 1.4 | 157.3 | 00 | 565 | Lag 2 | 1*216 + 27*200 | Variable groupC77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Tilpasses bergoverflate; K-M05 Korrigert lengde max.: 3840; K-M13 A max.: 3840
ARMERING | 20 | B500NC | P3018 | 4 | 3910 | 15640 | 9.6 | 38.6 | 00 | 3910 | - | 1*146 + 2*200 | BF2D@Hj10259741-01@rMC@i01@pP3018@l3910@n1@e9.64@d20@gB500NC@s0@a0@t0@Gl3910@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Vegg
ARMERING | 20 | B500NC | P3018 | 4 | 3910 | 15640 | 9.6 | 38.6 | 00 | 3910 | - | 1*56 + 2*200 | BF2D@Hj10259741-01@rMC@i01@pP3018@l3910@n1@e9.64@d20@gB500NC@s0@a0@t0@Gl3910@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Vegg
ARMERING | 20 | B500NC | P3017 | 10 | 5110 | 51100 | 12.6 | 126.1 | 21 | 2400 | YK | 1*125 + 8*200 | BF2D@Hj10259741-01@rMC@i01@pP3017@l5115@n1@e12.6@d20@gB500NC@s80@a0@t0@Gl2400@w90@l410@w90@l2400@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Konsollarmering | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 2400; K-M33 Merknader til utførelse 1: Tilpasses mot berg
ARMERING | 20 | B500NC | P3016 | 7 | 3380 | 23660 | 8.3 | 58.4 | 99-100 | 2000 | YK | 1*45 + 5*100 | BF2D@Hj10259741-01@rMC@i01@pP3016@l3380@n1@e8.34@d20@gB500NC@s80@a0@t0@Gl2000@w54@l1400@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Konsollarmering | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 1400
ARMERING | 20 | B500NC | P3015 | 3 | 4355 | 13065 | 10.7 | 32.2 | 00 | 4355 | - | 1*185 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP3015@l4355@n1@e10.74@d20@gB500NC@s0@a0@t0@Gl4355@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Vegg
ARMERING | 25 | B500NC | P5024 | 4 | 8295 | 33180 | 32 | 127.9 | 00 | 8295 | UK | 1*100 + 1*90 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5024@l8295@n1@e13.09@d16@gB500NC@s0@a0@t0@Gl8295@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 25 | B500NC | P5024 | 4 | 8295 | 33180 | 32 | 127.9 | 00 | 8295 | OK | 1*100 + 1*90 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5024@l8295@n1@e13.09@d16@gB500NC@s0@a0@t0@Gl8295@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 25 | B500NC | P5023 | 4 | 6000 | 24000 | 23.1 | 92.5 | 00 | 6000 | UK | 1*100 + 1*90 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5023@l6000@n1@e9.47@d16@gB500NC@s0@a0@t0@Gl6000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 25 | B500NC | P5023 | 4 | 6000 | 24000 | 23.1 | 92.5 | 00 | 6000 | OK | 1*100 + 1*90 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5023@l6000@n1@e9.47@d16@gB500NC@s0@a0@t0@Gl6000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
2 x ARMERING | 25 | B500NC | P5011 | 4 | 12000 | 48000 | 46.2 | 184.9 | 00 | 12000 | UK | 1*100 + 1*90 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5011@l12000@n1@e46.24@d25@gB500NC@s0@a0@t0@Gl12000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
2 x ARMERING | 25 | B500NC | P5011 | 4 | 12000 | 48000 | 46.2 | 184.9 | 00 | 12000 | OK | 1*100 + 1*90 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5011@l12000@n1@e46.24@d25@gB500NC@s0@a0@t0@Gl12000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 25 | B500NC | P5021 | 4 | 9000 | 36000 | 34.7 | 138.7 | 00 | 9000 | UK | 1*100 + 1*90 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5021@l9000@n1@e14.2@d16@gB500NC@s0@a0@t0@Gl9000@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 25 | B500NC | P5021 | 4 | 9000 | 36000 | 34.7 | 138.7 | 00 | 9000 | OK | 1*100 + 1*90 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5021@l9000@n1@e14.2@d16@gB500NC@s0@a0@t0@Gl9000@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 25 | B500NC | P5020 | 4 | 5310 | 21240 | 20.5 | 81.9 | 00 | 5310 | OK | 1*100 + 1*60 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5020@l5310@n1@e8.38@d16@gB500NC@s0@a0@t0@Gl5310@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 25 | B500NC | P5020 | 4 | 5310 | 21240 | 20.5 | 81.9 | 00 | 5310 | UK | 1*100 + 1*90 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5020@l5310@n1@e8.38@d16@gB500NC@s0@a0@t0@Gl5310@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5019 | 4 | 5885 | 23540 | 9.3 | 37.1 | 00 | 5885 | OK | 3*100 | BF2D@Hj10259741-01@rMC@i01@pP5019@l5885@n1@e9.29@d16@gB500NC@s0@a0@t0@Gl5885@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5019 | 4 | 5885 | 23540 | 9.3 | 37.1 | 00 | 5885 | UK | 3*100 | BF2D@Hj10259741-01@rMC@i01@pP5019@l5885@n1@e9.29@d16@gB500NC@s0@a0@t0@Gl5885@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5017 | 10 | 1820 | 18200 | 2.9 | 28.7 | 21 | 800 | SK | 4*200 + 1*172 + 4*200 | BF2D@Hj10259741-01@rMC@i01@pP5017@l1820@n1@e2.87@d16@gB500NC@s50@a0@t0@Gl800@w90@l290@w90@l800@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 290; K-M16 C/C min.: 800
ARMERING | 20 | B500NC | P5016 | 20 | 2230 | 44600 | 5.5 | 110.2 | 21 | 1000 | SK | 9*200 + 1*25 + 9*200 | BF2D@Hj10259741-01@rMC@i01@pP5016@l2235@n1@e5.5@d20@gB500NC@s80@a0@t0@Gl1000@w90@l330@w90@l1000@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 1000
ARMERING | 25 | B500NC | P5018 | 28 | 7740 | 216720 | 29.8 | 835.4 | 21 | 3800 | SK | 1*40 + 26*200 | BF2D@Hj10259741-01@rMC@i01@pP5018@l7740@n1@e29.82@d25@gB500NC@s125@a0@t0@Gl3800@w90@l270@w90@l3800@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 270; K-M16 C/C min.: 3800
ARMERING | 16 | B500NC | P5017 | 7 | 1820 | 12740 | 2.9 | 20.1 | 21 | 800 | SK | 6*200 | BF2D@Hj10259741-01@rMC@i01@pP5017@l1820@n1@e2.87@d16@gB500NC@s50@a0@t0@Gl800@w90@l290@w90@l800@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 290; K-M16 C/C min.: 800
ARMERING | 16 | B500NC | P5015 | 41 | 1860 | 76260 | 2.9 | 120.3 | 21 | 800 | SK | 20*200 + 1*50 + 19*200 | BF2D@Hj10259741-01@rMC@i01@pP5015@l1860@n1@e2.94@d16@gB500NC@s50@a0@t0@Gl800@w90@l330@w90@l800@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 800
ARMERING | 20 | B500NC | P5016 | 9 | 2230 | 20070 | 5.5 | 49.6 | 21 | 1000 | SK | 4*200 + 1*135 + 3*200 | BF2D@Hj10259741-01@rMC@i01@pP5016@l2235@n1@e5.5@d20@gB500NC@s80@a0@t0@Gl1000@w90@l330@w90@l1000@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 1000
ARMERING | 16 | B500NC | P5015 | 42 | 1860 | 78120 | 2.9 | 123.3 | 21 | 800 | SK | 20*200 + 1*40 + 20*200 | BF2D@Hj10259741-01@rMC@i01@pP5015@l1860@n1@e2.94@d16@gB500NC@s50@a0@t0@Gl800@w90@l330@w90@l800@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 800
ARMERING | 16 | B500NC | P5015 | 27 | 1860 | 50220 | 2.9 | 79.2 | 21 | 800 | SK | 13*200 + 1*169 + 12*200 | BF2D@Hj10259741-01@rMC@i01@pP5015@l1860@n1@e2.94@d16@gB500NC@s50@a0@t0@Gl800@w90@l330@w90@l800@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 800
ARMERING | 16 | B500NC | P5014 | 30 | 1815 | 54450 | 2.9 | 85.9 | 21 | 800 | SK | 14*200 + 1*187 + 14*200 | BF2D@Hj10259741-01@rMC@i01@pP5014@l1815@n1@e2.86@d16@gB500NC@s50@a0@t0@Gl800@w90@l285@w90@l800@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 285; K-M16 C/C min.: 800
ARMERING | 25 | B500NC | P5013 | 8 | 3535 | 28280 | 13.6 | 109 | 11 | 1800 | SK | 3*200 + 2*105 + 1*140 + 1*190 | BF2D@Hj10259741-01@rMC@i01@pP5013@l3535@n1@e13.62@d25@gB500NC@s125@a0@t0@Gl1800@w90@l1800@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 1800
ARMERING | 25 | B500NC | P5013 | 8 | 3535 | 28280 | 13.6 | 109 | 11 | 1800 | SK | 1*160 + 1*200 + 1*100 + 1*120 + 1*200 + 1*105 + 1*215 | BF2D@Hj10259741-01@rMC@i01@pP5013@l3535@n1@e13.62@d25@gB500NC@s125@a0@t0@Gl1800@w90@l1800@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 1800
ARMERING | 25 | B500NC | P5048 | 12 | 3640 | 43680 | 14 | 168.4 | 21 | 1250 | SK | 10*200 + 1*140 | BF2D@Hj10259741-01@rMC@i01@pP5048@l3640@n1@e14.03@d25@gB500NC@s125@a0@t0@Gl1250@w90@l1265@w90@l1250@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 1265; K-M16 C/C min.: 1250
ARMERING | 25 | B500NC | P5013 | 8 | 3535 | 28280 | 13.6 | 109 | 11 | 1800 | SK | 1*115 + 2*200 + 2*100 + 1*200 + 1*175 | BF2D@Hj10259741-01@rMC@i01@pP5013@l3535@n1@e13.62@d25@gB500NC@s125@a0@t0@Gl1800@w90@l1800@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 1800
ARMERING | 25 | B500NC | P5013 | 7 | 3535 | 24745 | 13.6 | 95.4 | 11 | 1800 | SK | 1*160 + 1*200 + 1*220 + 1*265 + 1*105 + 1*125 | BF2D@Hj10259741-01@rMC@i01@pP5013@l3535@n1@e13.62@d25@gB500NC@s125@a0@t0@Gl1800@w90@l1800@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 1800
ARMERING | 25 | B500NC | P5012 | 13 | 7140 | 92820 | 27.5 | 357.7 | 21 | 3000 | YK | 11*200 + 1*30 | BF2D@Hj10259741-01@rMC@i01@pP5012@l7140@n1@e27.51@d25@gB500NC@s125@a0@t0@Gl3000@w90@l1265@w90@l3000@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 1265; K-M16 C/C min.: 3000
ARMERING | 20 | B500NC | P5047 | 12 | 10400 | 124800 | 25.6 | 307.8 | 00 | 10400 | SK | 5*200 + 1*25 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP5047@l10400@n1@e25.65@d20@gB500NC@s0@a0@t0@Gl10400@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Bjelke
ARMERING | 20 | B500NC | P5047 | 12 | 10400 | 124800 | 25.6 | 307.8 | 00 | 10400 | SK | 5*200 + 1*85 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP5047@l10400@n1@e25.65@d20@gB500NC@s0@a0@t0@Gl10400@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Bjelke
ARMERING | 25 | B500NC | P5011 | 6 | 12000 | 72000 | 46.2 | 277.4 | 00 | 12000 | OK | 1*170 + 1*200 + 1*120 + 1*100 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP5011@l12000@n1@e46.24@d25@gB500NC@s0@a0@t0@Gl12000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Bjelke
2 x ARMERING | 25 | B500NC | P5011 | 8 | 12000 | 96000 | 46.2 | 369.9 | 00 | 12000 | UK | 3*200 + 2*104 + 2*200 | BF2D@Hj10259741-01@rMC@i01@pP5011@l12000@n1@e46.24@d25@gB500NC@s0@a0@t0@Gl12000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Bjelke
ARMERING | 25 | B500NC | P5011 | 8 | 12000 | 96000 | 46.2 | 369.9 | 00 | 12000 | OK | 1*200 + 1*170 + 1*200 + 1*120 + 1*100 + 1*200 + 1*230 | BF2D@Hj10259741-01@rMC@i01@pP5011@l12000@n1@e46.24@d25@gB500NC@s0@a0@t0@Gl12000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Bjelke
ARMERING | 16 | B500NC | P5010 | 9 | 7245 | 65205 | 11.4 | 102.9 | 00 | 7245 | OK | 4*200 + 1*177 + 3*200 | BF2D@Hj10259741-01@rMC@i01@pP5010@l7245@n1@e11.43@d16@gB500NC@s0@a0@t0@Gl7245@w0@C92@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
ARMERING | 16 | B500NC | P5009 | 9 | 7100 | 63900 | 11.2 | 100.8 | 00 | 7100 | UK | 4*200 + 1*126 + 3*200 | BF2D@Hj10259741-01@rMC@i01@pP5009@l7100@n1@e11.2@d16@gB500NC@s0@a0@t0@Gl7100@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
ARMERING | 16 | B500NC | P5008 | 7 | 3210 | 22470 | 5.1 | 35.5 | 00 | 3210 | UK | 3*200 + 1*170 + 2*200 | BF2D@Hj10259741-01@rMC@i01@pP5008@l3210@n1@e5.07@d16@gB500NC@s0@a0@t0@Gl3210@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 16 | B500NC | P5008 | 8 | 3210 | 25680 | 5.1 | 40.5 | 00 | 3210 | OK | 3*200 + 1*20 + 3*200 | BF2D@Hj10259741-01@rMC@i01@pP5008@l3210@n1@e5.07@d16@gB500NC@s0@a0@t0@Gl3210@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 20 | B500NC | P5007 | 9 | 6580 | 59220 | 16.2 | 146.1 | 21 | 2480 | UK | 8*200 | BF2D@Hj10259741-01@rMC@i01@pP5007@l6580@n1@e16.23@d20@gB500NC@s80@a0@t0@Gl165@w180@l2480@w90@l1315@w90@l2480@w180@l165@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 1315; K-M10 Krok Start: 3; K-M16 C/C min.: 2480
ARMERING | 16 | B500NC | P5006 | 14 | 12000 | 168000 | 18.9 | 265.1 | 00 | 12000 | UK | 6*400 + 1*410 + 6*400 | BF2D@Hj10259741-01@rMC@i01@pP5006@l12000@n1@e18.94@d16@gB500NC@s0@a0@t0@Gl12000@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
ARMERING | 16 | B500NC | P5006 | 14 | 12000 | 168000 | 18.9 | 265.1 | 00 | 12000 | OK | 6*400 + 1*410 + 6*400 | BF2D@Hj10259741-01@rMC@i01@pP5006@l12000@n1@e18.94@d16@gB500NC@s0@a0@t0@Gl12000@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
ARMERING | 16 | B500NC | P5005 | 15 | 10700 | 160500 | 16.9 | 253.3 | 00 | 10700 | UK | 7*400 + 1*132 + 6*400 | BF2D@Hj10259741-01@rMC@i01@pP5005@l10360@n1@e16.35@d16@gB500NC@s0@a0@t0@Gl10360@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Armering kappes og tilpasses; K-M34 Merknader til utførelse 2: Omfaringslengde 50*Ø
ARMERING | 16 | B500NC | P5005 | 15 | 10700 | 160500 | 16.9 | 253.3 | 00 | 10700 | OK | 7*400 + 1*132 + 6*400 | BF2D@Hj10259741-01@rMC@i01@pP5005@l10360@n1@e16.35@d16@gB500NC@s0@a0@t0@Gl10360@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Armering kappes og tilpasses; K-M34 Merknader til utførelse 2: Omfaringslengde 50*Ø
ARMERING | 20 | B500NC | P5004 | 13 | 12000 | 156000 | 29.6 | 384.7 | 00 | 12000 | UK | 6*400 + 1*409 + 5*400 | BF2D@Hj10259741-01@rMC@i01@pP5004@l9995@n1@e24.65@d20@gB500NC@s0@a0@t0@Gl9995@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
ARMERING | 20 | B500NC | P5004 | 13 | 12000 | 156000 | 29.6 | 384.7 | 00 | 12000 | OK | 6*400 + 1*409 + 5*400 | BF2D@Hj10259741-01@rMC@i01@pP5004@l9995@n1@e24.65@d20@gB500NC@s0@a0@t0@Gl9995@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
ARMERING | 16 | B500NC | P5046 | 6 | 7210 | 43260 | 11.4 | 68.3 | 00 | 7210 | OK | 5*200 | BF2D@Hj10259741-01@rMC@i01@pP5046@l7210@n1@e11.38@d16@gB500NC@s0@a0@t0@Gl7210@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 16 | B500NC | P5046 | 6 | 7210 | 43260 | 11.4 | 68.3 | 00 | 7210 | UK | 5*200 | BF2D@Hj10259741-01@rMC@i01@pP5046@l7210@n1@e11.38@d16@gB500NC@s0@a0@t0@Gl7210@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 16 | B500NC | P5003 | 67 | 5190 | 414562 | 8.2 | 615 | 00 | 5190 | OK | 33*200 + 1*40 + 32*200 | Variable groupC77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke | Brattvåg-Dryna armering - K-M05 Korrigert lengde max.: 7185; K-M13 A max.: 7185
ARMERING | 16 | B500NC | P5002 | 66 | 5190 | 408210 | 8.2 | 606 | 00 | 5190 | UK | 65*200 | Variable groupC77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke | Brattvåg-Dryna armering - K-M05 Korrigert lengde max.: 7180; K-M13 A max.: 7180
ARMERING | 20 | B500NC | P5001 | 20 | 5810 | 116200 | 14.3 | 286.6 | 00 | 5810 | OK | 9*200 + 1*75 + 9*200 | BF2D@Hj10259741-01@rMC@i01@pP5001@l5810@n1@e14.33@d20@gB500NC@s0@a0@t0@Gl5810@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 20 | B500NC | P5001 | 20 | 5810 | 116200 | 14.3 | 286.6 | 00 | 5810 | UK | 9*200 + 1*75 + 9*200 | BF2D@Hj10259741-01@rMC@i01@pP5001@l5810@n1@e14.33@d20@gB500NC@s0@a0@t0@Gl5810@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 20 | B500NC | P5045 | 6 | 4405 | 26430 | 10.9 | 65.2 | 00 | 4405 | OK | 2*400 + 1*285 + 2*400 | BF2D@Hj10259741-01@rMC@i01@pP5045@l3905@n1@e9.63@d20@gB500NC@s0@a0@t0@Gl3905@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 20 | B500NC | P5045 | 6 | 4405 | 26430 | 10.9 | 65.2 | 00 | 4405 | UK | 2*400 + 1*285 + 2*400 | BF2D@Hj10259741-01@rMC@i01@pP5045@l3905@n1@e9.63@d20@gB500NC@s0@a0@t0@Gl3905@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 20 | B500NC | P5001 | 10 | 5810 | 58100 | 14.3 | 143.3 | 00 | 5810 | OK | 4*200 + 1*60 + 4*200 | BF2D@Hj10259741-01@rMC@i01@pP5001@l5810@n1@e14.33@d20@gB500NC@s0@a0@t0@Gl5810@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5000 | 40 | 5810 | 232400 | 9.2 | 366.9 | 00 | 5810 | UK | 19*200 + 1*190 + 19*200 | BF2D@Hj10259741-01@rMC@i01@pP5000@l5810@n1@e9.17@d16@gB500NC@s0@a0@t0@Gl5810@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
2 x ARMERING | 16 | B500NC | P4013 | 8 | 4885 | 39080 | 7.7 | 61.7 | 00 | 4885 | Lag 2 | 7*155 | BF2D@Hj10259741-01@rMC@i01@pP4013@l4885@n1@e7.71@d16@gB500NC@s0@a0@t0@Gl4885@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Utstøpt heisetårn
2 x ARMERING | 16 | B500NC | P4012 | 12 | 1700 | 20400 | 2.7 | 32.2 | 67 | 1705 | Lag 1 | 11*240 |  | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Utstøpt heisetårn
9 x ARMERING | 20 | B500NC | P4001 | 24 | 1310 | 31440 | 3.2 | 77.5 | 00 | 1310 | Lag 2 | 23*176 | BF2D@Hj10259741-01@rMC@i01@pP4001@l1310@n1@e3.23@d20@gB500NC@s0@a0@t0@Gl1310@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kumring
9 x ARMERING | 16 | B500NC | P4000 | 10 | 5455 | 54550 | 8.6 | 86.1 | 67 | 5455 | Lag 1 | 9*150 |  | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Kumring
ARMERING | 32 | B500NC | P4011 | 12 | 4755 | 57060 | 30 | 360.5 | 00 | 4755 | Lag 2 | 11*135 | BF2D@Hj10259741-01@rMC@i01@pP4011@l4755@n1@e30.02@d32@gB500NC@s0@a0@t0@Gl4755@w0@C92@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Utstøpt heisetårn
ARMERING | 16 | B500NC | P4006 | 19 | 2250 | 42750 | 3.6 | 67.5 | 67 | 2255 | Lag 1 | 18*146 |  | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Utstøpt heisetårn
ARMERING | 32 | B500NC | P4010 | 15 | 10135 | 152025 | 64 | 960.1 | 00 | 10135 | Lag 2 | 14*120 | BF2D@Hj10259741-01@rMC@i01@pP4010@l10135@n1@e63.98@d32@gB500NC@s0@a0@t0@Gl10135@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Utstøpt heisetårn | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Utføres med T-hoder HRC110 eller tilsvarende
ARMERING | 16 | B500NC | P4009 | 59 | 2485 | 146615 | 3.9 | 231.5 | 67 | 2490 | Lag 1 | 58*149 |  | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Utstøpt heisetårn
2 x ARMERING | 20 | B500NC | P2024 | 2 | 4530 | 9060 | 11.2 | 22.3 | 31 | 1100 | OK | 1*125 | BF2D@Hj10259741-01@rMC@i01@pP2024@l4530@n1@e11.17@d20@gB500NC@s80@a0@t0@Gl265@w90@l1100@w90@l1020@w90@l1100@w90@l1020@w90@l265@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 1020; K-M10 Krok Start: 1; K-M16 C/C min.: 1100; K-M18 D/D min.: 1020
ARMERING | 20 | B500NC | P2023 | 9 | 2660 | 23940 | 6.6 | 59.1 | 21 | 850 | OK | 4*150 + 1*35 + 3*150 | BF2D@Hj10259741-01@rMC@i01@pP2023@l2665@n1@e6.56@d20@gB500NC@s80@a0@t0@Gl850@w90@l1060@w90@l850@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 1060; K-M16 C/C min.: 850
ARMERING | 20 | B500NC | P2028 | 8 | 2750 | 22000 | 6.8 | 54.3 | 21 | 850 | OK | 1*120 + 5*150 + 1*120 | BF2D@Hj10259741-01@rMC@i01@pP2028@l2755@n1@e6.78@d20@gB500NC@s80@a0@t0@Gl850@w90@l1150@w90@l850@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 1150; K-M16 C/C min.: 850
2 x ARMERING | 20 | B500NC | P2027 | 2 | 3845 | 7690 | 9.5 | 19 | 31 | 1045 | OK | 1*125 | BF2D@Hj10259741-01@rMC@i01@pP2027@l3845@n1@e9.48@d20@gB500NC@s80@a0@t0@Gl265@w90@l730@w90@l1045@w90@l735@w90@l1045@w90@l265@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 735; K-M10 Krok Start: 1; K-M16 C/C min.: 1045; K-M18 D/D min.: 730
2 x ARMERING | 20 | B500NC | P2026 | 6 | 2690 | 16140 | 6.6 | 39.9 | 21 | 850 | OK | 2*150 + 1*125 + 2*150 | BF2D@Hj10259741-01@rMC@i01@pP2026@l2695@n1@e6.63@d20@gB500NC@s80@a0@t0@Gl850@w90@l1090@w90@l850@w0@C65@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 1090; K-M16 C/C min.: 850
2 x ARMERING | 20 | B500NC | P2025 | 8 | 2410 | 19280 | 5.9 | 47.6 | 21 | 850 | OK | 3*150 + 1*115 + 3*150 | BF2D@Hj10259741-01@rMC@i01@pP2025@l2415@n1@e5.94@d20@gB500NC@s80@a0@t0@Gl850@w90@l810@w90@l850@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 810; K-M16 C/C min.: 850
ARMERING | 20 | B500NC | P2023 | 9 | 2660 | 23940 | 6.6 | 59.1 | 21 | 850 | OK | 1*92 + 6*150 + 1*92 | BF2D@Hj10259741-01@rMC@i01@pP2023@l2665@n1@e6.56@d20@gB500NC@s80@a0@t0@Gl850@w90@l1060@w90@l850@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 1060; K-M16 C/C min.: 850
ARMERING | 20 | B500NC | P2022 | 8 | 2850 | 22800 | 7 | 56.3 | 21 | 850 | OK | 3*150 + 1*90 + 3*150 | BF2D@Hj10259741-01@rMC@i01@pP2022@l2855@n1@e7.03@d20@gB500NC@s80@a0@t0@Gl850@w90@l1250@w90@l850@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 1250; K-M16 C/C min.: 850
ARMERING | 16 | B500NC | P2017 | 5 | 5960 | 29800 | 9.4 | 47 | 21 | 2010 | OK | 2*150 + 1*140 + 1*150 | BF2D@Hj10259741-01@rMC@i01@pP2017@l5960@n1@e9.41@d16@gB500NC@s50@a0@t0@Gl2010@w90@l2010@w90@l2010@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 2010; K-M16 C/C min.: 2010
ARMERING | 25 | B500NC | P2016 | 5 | 12000 | 60000 | 46.2 | 231.2 | 00 | 12000 | OK | 1*180 + 1*150 + 1*200 + 1*110 | BF2D@Hj10259741-01@rMC@i01@pP2016@l12000@n1@e46.24@d25@gB500NC@s0@a0@t0@Gl12000@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 16 | B500NC | P2001 | 5 | 12000 | 60000 | 18.9 | 94.7 | 00 | 12000 | SK | 1*140 + 3*150 | BF2D@Hj10259741-01@rMC@i01@pP2001@l12000@n1@e18.94@d16@gB500NC@s0@a0@t0@Gl12000@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 16 | B500NC | P2021 | 82 | 1950 | 159900 | 3.1 | 252.9 | 11 | 1225 | SK | 40*150 + 1*30 + 40*150 | BF2D@Hj10259741-01@rMC@i01@pP2021@l1950@n1@e3.08@d16@gB500NC@s50@a0@t0@Gl1225@w90@l760@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 755
ARMERING | 16 | B500NC | P2001 | 3 | 12000 | 36000 | 18.9 | 56.8 | 00 | 12000 | SK | 2*180 | BF2D@Hj10259741-01@rMC@i01@pP2001@l12000@n1@e18.94@d16@gB500NC@s0@a0@t0@Gl12000@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 12 | B500NCR | P2020 | 83 | 1190 | 98770 | 1.1 | 90.1 | 26 | 800 | - | 41*150 + 1*125 + 40*150 | BF2D@Hj10259741-01@rMC@i01@pP2020@l1190@n1@e1.08@d12@gB500NCR@s32@a0@t0@Gl230@w63@l185@w-63@l800@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Overgangsplate | Brattvåg-Dryna armering - K-M14 B/B min.: 185; K-M16 C/C min.: 230; K-M18 D/D min.: 170; K-M33 Merknader til utførelse 1: Rustfritt stål; K-M34 Merknader til utførelse 2: Midlertidig posisjon av forankringsjern; K-M35 Merknader til utførelse 3: Bøyes til endelig posisjon etter fylling og komprimering.; K-M36 Andre merknader 1: Bøyes ikke i krympeplastområdet
2 x ARMERING | 20 | B500NC | P2010 | 2 | 2005 | 4010 | 4.9 | 9.9 | 00 | 2005 | - | 1*608 | BF2D@Hj10259741-01@rMC@i01@pP2010@l2010@n1@e4.94@d20@gB500NC@s0@a0@t0@Gl2010@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Landkar
2 x ARMERING | 20 | B500NC | P2006 | 14 | 2510 | 35140 | 6.2 | 86.8 | 21 | 1000 | OK | 12*150 + 1*45 | BF2D@Hj10259741-01@rMC@i01@pP2006@l2510@n1@e6.19@d20@gB500NC@s80@a0@t0@Gl1000@w90@l605@w90@l1000@w0@C87@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 605; K-M16 C/C min.: 1000
2 x ARMERING | 20 | B500NC | P2005 | 14 | 4945 | 69230 | 12.2 | 170.7 | 21 | 2015 | UK | 12*150 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP2005@l4945@n1@e12.19@d20@gB500NC@s80@a0@t0@Gl165@w180@l2015@w90@l610@w90@l2015@w180@l165@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 610; K-M10 Krok Start: 3; K-M16 C/C min.: 2015
ARMERING | 20 | B500NC | P2019 | 8 | 1960 | 15680 | 4.8 | 38.7 | 00 | 1960 | SK | 6*150 + 1*109 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 20 | B500NC | P2019 | 8 | 1960 | 15680 | 4.8 | 38.7 | 00 | 1960 | SK | 1*109 + 6*150 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 20 | B500NC | P2000 | 6 | 12000 | 72000 | 29.6 | 177.6 | 00 | 12000 | SK | 4*150 + 1*125 | BF2D@Hj10259741-01@rMC@i01@pP2000@l12000@n1@e29.59@d20@gB500NC@s0@a0@t0@Gl12000@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 20 | B500NC | P2018 | 73 | 4855 | 354415 | 12 | 874 | 21 | 1995 | UK | 71*150 + 1*115 | BF2D@Hj10259741-01@rMC@i01@pP2018@l4855@n1@e11.97@d20@gB500NC@s80@a0@t0@Gl165@w180@l1995@w90@l560@w90@l1995@w180@l165@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 560; K-M10 Krok Start: 3; K-M16 C/C min.: 1995
ARMERING | 20 | B500NC | P2002 | 73 | 2460 | 179580 | 6.1 | 443.7 | 21 | 1000 | OK | 71*150 + 1*65 | BF2D@Hj10259741-01@rMC@i01@pP2002@l2460@n1@e6.07@d20@gB500NC@s80@a0@t0@Gl1000@w90@l555@w90@l1000@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 555; K-M16 C/C min.: 1000
2 x ARMERING | 20 | B500NC | P2002 | 8 | 2460 | 19680 | 6.1 | 48.6 | 21 | 1000 | SK | 6*150 + 1*114 | BF2D@Hj10259741-01@rMC@i01@pP2002@l2460@n1@e6.07@d20@gB500NC@s80@a0@t0@Gl1000@w90@l555@w90@l1000@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 555; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P2000 | 8 | 12000 | 96000 | 29.6 | 236.7 | 00 | 12000 | SK | 1*105 + 6*150 | BF2D@Hj10259741-01@rMC@i01@pP2000@l12000@n1@e29.59@d20@gB500NC@s0@a0@t0@Gl12000@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 20 | B500NC | P2000 | 2 | 12000 | 24000 | 29.6 | 59.2 | 00 | 12000 | SK | 1*150 | BF2D@Hj10259741-01@rMC@i01@pP2000@l12000@n1@e29.59@d20@gB500NC@s0@a0@t0@Gl12000@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 20 | B500NC | P2000 | 4 | 12000 | 48000 | 29.6 | 118.4 | 00 | 12000 | OK | 2*150 + 1*125 | BF2D@Hj10259741-01@rMC@i01@pP2000@l12000@n1@e29.59@d20@gB500NC@s0@a0@t0@Gl12000@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 16 | B500NC | P2009 | 5 | 6060 | 30300 | 9.6 | 47.8 | 21 | 2010 | OK | 2*150 + 1*140 + 1*150 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 2110; K-M16 C/C min.: 2010
ARMERING | 25 | B500NC | P2016 | 11 | 12000 | 132000 | 46.2 | 508.6 | 00 | 12000 | OK | 1*135 + 4*150 + 1*200 + 1*75 + 3*150 | BF2D@Hj10259741-01@rMC@i01@pP2016@l12000@n1@e46.24@d25@gB500NC@s0@a0@t0@Gl12000@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 20 | B500NC | P2015 | 8 | 2060 | 16480 | 5.1 | 40.6 | 00 | 2060 | SK | 1*109 + 6*150 | BF2D@Hj10259741-01@rMC@i01@pP2015@l1960@n1@e4.83@d20@gB500NC@s0@a0@t0@Gl1960@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 20 | B500NC | P2015 | 8 | 2060 | 16480 | 5.1 | 40.6 | 00 | 2060 | SK | 6*150 + 1*109 | BF2D@Hj10259741-01@rMC@i01@pP2015@l1960@n1@e4.83@d20@gB500NC@s0@a0@t0@Gl1960@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
2 x ARMERING | 16 | B500NC | P2014 | 5 | 4575 | 22875 | 7.2 | 36.1 | 21 | 1200 | SK | 3*150 + 1*152 | BF2D@Hj10259741-01@rMC@i01@pP2014@l4580@n1@e7.22@d16@gB500NC@s50@a0@t0@Gl1200@w90@l2250@w90@l1200@w0@C96@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 2245; K-M16 C/C min.: 1200
2 x ARMERING | 20 | B500NC | P2013 | 13 | 3010 | 39130 | 7.4 | 96.6 | 21 | 1200 | UK | 11*150 + 1*144 | BF2D@Hj10259741-01@rMC@i01@pP2013@l3010@n1@e7.42@d20@gB500NC@s80@a0@t0@Gl1200@w90@l705@w90@l1200@w0@C91@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 705; K-M16 C/C min.: 1200
ARMERING | 20 | B500NC | P2012 | 8 | 2815 | 22520 | 6.9 | 55.5 | 21 | 1200 | SK | 6*150 + 1*19 | BF2D@Hj10259741-01@rMC@i01@pP2012@l2815@n1@e6.94@d20@gB500NC@s80@a0@t0@Gl1200@w90@l510@w90@l1200@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 510; K-M16 C/C min.: 1200
ARMERING | 20 | B500NC | P2011 | 7 | 2860 | 20020 | 7.1 | 49.4 | 21 | 1200 | SK | 5*150 + 1*99 | BF2D@Hj10259741-01@rMC@i01@pP2011@l2865@n1@e7.05@d20@gB500NC@s80@a0@t0@Gl1200@w90@l560@w90@l1200@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 560; K-M16 C/C min.: 1200
2 x ARMERING | 20 | B500NC | P2002 | 8 | 2460 | 19680 | 6.1 | 48.6 | 21 | 1000 | SK | 6*150 + 1*114 | BF2D@Hj10259741-01@rMC@i01@pP2002@l2460@n1@e6.07@d20@gB500NC@s80@a0@t0@Gl1000@w90@l555@w90@l1000@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 560; K-M16 C/C min.: 1000
4 x ARMERING | 20 | B500NC | P2008 | 2 | 2765 | 5530 | 6.8 | 13.6 | 21 | 275 | - | 1*139 | BF2D@Hj10259741-01@rMC@i01@pP2008@l2765@n1@e6.82@d20@gB500NC@s80@a0@t0@Gl275@w90@l2310@w90@l275@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 2310; K-M16 C/C min.: 275
ARMERING | 20 | B500NC | P2000 | 2 | 12000 | 24000 | 29.6 | 59.2 | 00 | 12000 | - | 1*215 | BF2D@Hj10259741-01@rMC@i01@pP2000@l12000@n1@e29.59@d20@gB500NC@s0@a0@t0@Gl12000@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 20 | B500NC | P2000 | 2 | 12000 | 24000 | 29.6 | 59.2 | 00 | 12000 | - | 1*225 | BF2D@Hj10259741-01@rMC@i01@pP2000@l12000@n1@e29.59@d20@gB500NC@s0@a0@t0@Gl12000@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
2 x ARMERING | 20 | B500NC | P2003 | 3 | 3510 | 10530 | 8.7 | 26 | 21 | 1200 | UK | 1*150 + 1*41 | BF2D@Hj10259741-01@rMC@i01@pP2003@l3510@n1@e8.66@d20@gB500NC@s80@a0@t0@Gl1200@w90@l1205@w90@l1200@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 1205; K-M16 C/C min.: 1200
ARMERING | 25 | B500NC | P2004 | 20 | 3685 | 73700 | 14.2 | 284.2 | 21 | 750 | UK | 9*150 + 1*30 + 9*150 | BF2D@Hj10259741-01@rMC@i01@pP2004@l3685@n1@e14.2@d25@gB500NC@s125@a0@t0@Gl750@w90@l2310@w90@l750@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 2305; K-M16 C/C min.: 750
ARMERING | 20 | B500NC | P2007 | 43 | 3715 | 159745 | 9.2 | 394.4 | 21 | 750 | UK | 21*150 + 1*75 + 20*150 | BF2D@Hj10259741-01@rMC@i01@pP2007@l3715@n1@e9.16@d20@gB500NC@s80@a0@t0@Gl750@w90@l2310@w90@l750@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 2305; K-M16 C/C min.: 750
ARMERING | 25 | B500NC | P2004 | 82 | 3685 | 302170 | 14.2 | 1165.3 | 21 | 750 | OK | 40*150 + 1*110 + 40*150 | BF2D@Hj10259741-01@rMC@i01@pP2004@l3685@n1@e14.2@d25@gB500NC@s125@a0@t0@Gl750@w90@l2310@w90@l750@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 2310; K-M16 C/C min.: 750
ARMERING | 25 | B500NC | P2004 | 20 | 3685 | 73700 | 14.2 | 284.2 | 21 | 750 | UK | 9*150 + 1*80 + 9*150 | BF2D@Hj10259741-01@rMC@i01@pP2004@l3685@n1@e14.2@d25@gB500NC@s125@a0@t0@Gl750@w90@l2310@w90@l750@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Landkar | Brattvåg-Dryna armering - K-M14 B/B min.: 2305; K-M16 C/C min.: 750
ARMERING | 16 | B500NC | P2001 | 5 | 12000 | 60000 | 18.9 | 94.7 | 00 | 12000 | SK | 2*150 + 1*57 + 1*150 | BF2D@Hj10259741-01@rMC@i01@pP2001@l12000@n1@e18.94@d16@gB500NC@s0@a0@t0@Gl12000@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 20 | B500NC | P2000 | 11 | 12000 | 132000 | 29.6 | 325.5 | 00 | 12000 | UK | 3*150 + 1*75 + 1*200 + 4*150 + 1*135 | BF2D@Hj10259741-01@rMC@i01@pP2000@l12000@n1@e29.59@d20@gB500NC@s0@a0@t0@Gl12000@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 20 | B500NC | P2000 | 5 | 12000 | 60000 | 29.6 | 148 | 00 | 12000 | UK | 1*110 + 1*200 + 1*150 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP2000@l12000@n1@e29.59@d20@gB500NC@s0@a0@t0@Gl12000@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
2 x ARMERING | 12 | B500NC | P1001 | 1 | 12000 | 12000 | 10.7 | 10.7 | 00 | 12000 | SK |  | BF2D@Hj10259741-01@rMC@i01@pP1001@l12000@n1@e10.66@d12@gB500NC@s0@a0@t0@Gl12000@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
2 x ARMERING | 12 | B500NC | P1004 | 20 | 1655 | 33100 | 1.5 | 29.5 | 21 | 800 | UK | 18*150 + 1*50 | BF2D@Hj10259741-01@rMC@i01@pP1004@l1660@n1@e1.47@d12@gB500NC@s32@a0@t0@Gl800@w90@l110@w90@l800@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Overgangsplate | Brattvåg-Dryna armering - K-M14 B/B min.: 110; K-M16 C/C min.: 800
2 x ARMERING | 16 | B500NC | P1002 | 1 | 12000 | 12000 | 18.9 | 18.9 | 00 | 12000 | SK |  | BF2D@Hj10259741-01@rMC@i01@pP1002@l12000@n1@e18.94@d16@gB500NC@s0@a0@t0@Gl12000@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Landkar
ARMERING | 12 | B500NC | P1005 | 2 | 2845 | 5690 | 2.5 | 5 | 00 | 2845 | OK | 1*100 | BF2D@Hj10259741-01@rMC@i01@pP1005@l2845@n1@e2.53@d12@gB500NC@s0@a0@t0@Gl2845@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Overgangsplate
ARMERING | 12 | B500NC | P1005 | 2 | 2845 | 5690 | 2.5 | 5 | 00 | 2845 | UK | 1*100 | BF2D@Hj10259741-01@rMC@i01@pP1005@l2845@n1@e2.53@d12@gB500NC@s0@a0@t0@Gl2845@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Overgangsplate
ARMERING | 12 | B500NC | P1005 | 2 | 2845 | 5690 | 2.5 | 5 | 00 | 2845 | OK | 1*150 | BF2D@Hj10259741-01@rMC@i01@pP1005@l2845@n1@e2.53@d12@gB500NC@s0@a0@t0@Gl2845@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Overgangsplate
ARMERING | 12 | B500NC | P1005 | 2 | 2845 | 5690 | 2.5 | 5 | 00 | 2845 | UK | 1*150 | BF2D@Hj10259741-01@rMC@i01@pP1005@l2845@n1@e2.53@d12@gB500NC@s0@a0@t0@Gl2845@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Overgangsplate
ARMERING | 16 | B500NC | P1003 | 83 | 1680 | 139440 | 2.7 | 220.4 | NB99-01 | 800 | UK | 41*150 + 1*120 + 40*150 | BF2D@Hj10259741-01@rMC@i01@pP1003@l1680@n1@e2.65@d16@gB500NC@s50@a0@t0@Gl800@w95.5@l140@w84.5@l800@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Overgangsplate | Brattvåg-Dryna armering - K-M14 B/B min.: 140; K-M16 C/C min.: 800
ARMERING | 12 | B500NC | P1001 | 20 | 12000 | 240000 | 10.7 | 213.1 | 00 | 12000 | UK | 18*150 + 1*50 | BF2D@Hj10259741-01@rMC@i01@pP1001@l12000@n1@e10.66@d12@gB500NC@s0@a0@t0@Gl12000@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Overgangsplate
ARMERING | 16 | B500NC | P1000 | 83 | 3135 | 260205 | 4.9 | 410.6 | NB99-01 | 200 | UK | 41*150 + 1*80 + 40*150 | BF2D@Hj10259741-01@rMC@i01@pP1000@l3135@n1@e4.95@d16@gB500NC@s50@a0@t0@Gl2850@w84.5@l140@w95.5@l200@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Overgangsplate | Brattvåg-Dryna armering - K-M14 B/B min.: 140; K-M16 C/C min.: 2850
3 x ARMERING | 12 | B500NC | P4002 | 39 | 2115 | 82485 | 1.9 | 73.4 | 67 | 2120 | Lag 1 | 38*196 |  | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Søyle
ARMERING | 12 | B500NC | P4002 | 21 | 2115 | 44415 | 1.9 | 39.5 | 67 | 2120 | Lag 1 | 20*198 |  | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Søyle
