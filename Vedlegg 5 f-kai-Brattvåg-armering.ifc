Properties of the parts of a building model (IFC2X3), part 2 of 4

# IfcReinforcingBar (1147)
Name | NominalDiameter (mm) = K-M03 Diameter | Material = K-M02 Kvalitet | K-M00 Pos. | K-M01 Antall | K-M04 Korrigert lengde min. | K-M06 Total lengde (m) | K-M07 Vekt pr. stk./Vekt pr. stk. min.(kg) | K-M08 Total vekt (kg) | K-M09 Form | K-M12 A/A min. | K-M29 Plassering | K-M30 Senteravstand | K-M32 BVBS enkeltjern | A04 Status MMI | A05 Link til notater | A06 Link til beskrivelser | A07 Link til tegninger | A09 Revisjonsdato | A10 Revisjonsmerknad | A00 Objektnavn = A01 Objektkode V440 = A02 Objektkode V770 = A03 Spesiell beskrivelse | A08 Revisjon | K-M28 Armeringslag | K-M31 Konstruksjonsdel
18 x ARMERING | 20 | B500NC | P4014 | 2 | 3430 | 6860 | 8.5 | 16.9 | 21 | 1300 | OK | 1*904 | BF2D@Hj10259741-01@rMC@i01@pP4014@l3435@n1@e8.46@d20@gB500NC@s80@a0@t0@Gl1300@w90@l930@w90@l1300@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Kumring | Brattvåg-Dryna armering - K-M14 B/B min.: 930; K-M16 C/C min.: 1300
9 x ARMERING | 20 | B500NC | P4016 | 2 | 3510 | 7020 | 8.7 | 17.3 | 21 | 1300 | OK | 1*904 | BF2D@Hj10259741-01@rMC@i01@pP4016@l3515@n1@e8.66@d20@gB500NC@s80@a0@t0@Gl1300@w90@l1010@w90@l1300@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Kumring | Brattvåg-Dryna armering - K-M14 B/B min.: 1010; K-M16 C/C min.: 1300
ARMERING | 20 | B500NC | P4018 | 2 | 2830 | 5660 | 7 | 14 | 21 | 1000 | OK | 1*974 | BF2D@Hj10259741-01@rMC@i01@pP4018@l2835@n1@e6.98@d20@gB500NC@s80@a0@t0@Gl1000@w90@l930@w90@l1000@w0@C96@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Kumring | Brattvåg-Dryna armering - K-M14 B/B min.: 930; K-M16 C/C min.: 1000
15 x ARMERING | 20 | B500NC | P4003 | 1 | 8670 | 8670 | 21.4 | 21.4 | 00 | 8670 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pP4003@l8670@n1@e21.38@d20@gB500NC@s0@a0@t0@Gl8670@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Søyle
12 x ARMERING | 20 | B500NC | P4017 | 1 | 8675 | 8675 | 21.4 | 21.4 | 00 | 8675 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pP4017@l8675@n1@e21.39@d20@gB500NC@s0@a0@t0@Gl8675@w0@C69@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Søyle
3 x ARMERING | 20 | B500NC | P4017 | 1 | 8680 | 8680 | 21.4 | 21.4 | 00 | 8680 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pP4017@l8675@n1@e21.39@d20@gB500NC@s0@a0@t0@Gl8675@w0@C69@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Søyle
ARMERING | 20 | B500NC | P4027 | 3 | 2550 | 7650 | 6.3 | 18.9 | 99-100 | 1500 | OK | 1*140 + 1*120 | BF2D@Hj10259741-01@rMC@i01@pP4027@l2550@n1@e6.29@d20@gB500NC@s80@a0@t0@Gl1500@w89@l1100@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Forankringsjern | Søyle | Brattvåg-Dryna armering - K-M14 B/B min.: 1100
3 x ARMERING | 20 | B500NC | P4024 | 2 | 2750 | 5500 | 6.8 | 13.6 | 11 | 1500 | OK | 1*280 | BF2D@Hj10259741-01@rMC@i01@pP4024@l2750@n1@e6.78@d20@gB500NC@s80@a0@t0@Gl1500@w90@l1300@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Forankringsjern | Søyle | Brattvåg-Dryna armering - K-M14 B/B min.: 1300
3 x ARMERING | 20 | B500NC | P4024 | 2 | 2750 | 5500 | 6.8 | 13.6 | 11 | 1500 | OK | 1*200 | BF2D@Hj10259741-01@rMC@i01@pP4024@l2750@n1@e6.78@d20@gB500NC@s80@a0@t0@Gl1500@w90@l1300@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Forankringsjern | Søyle | Brattvåg-Dryna armering - K-M14 B/B min.: 1300
ARMERING | 20 | B500NC | P4026 | 4 | 2750 | 11000 | 6.8 | 27.2 | NB99-16 | 1500 | OK | 1*80 + 1*132 + 1*130 | BF2D@Hj10259741-01@rMC@i01@pP4026@l2750@n1@e6.78@d20@gB500NC@s80@a0@t0@Gl1500@w91@l1300@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Forankringsjern | Søyle | Brattvåg-Dryna armering - K-M14 B/B min.: 1300
ARMERING | 20 | B500NC | P4027 | 4 | 2550 | 10200 | 6.3 | 25.2 | 99-100 | 1500 | OK | 1*90 + 1*130 + 1*60 | BF2D@Hj10259741-01@rMC@i01@pP4027@l2550@n1@e6.29@d20@gB500NC@s80@a0@t0@Gl1500@w89@l1100@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Forankringsjern | Søyle | Brattvåg-Dryna armering - K-M14 B/B min.: 1100
ARMERING | 20 | B500NC | P4026 | 4 | 2750 | 11000 | 6.8 | 27.2 | NB99-16 | 1500 | OK | 1*145 + 1*70 + 1*120 | BF2D@Hj10259741-01@rMC@i01@pP4026@l2750@n1@e6.78@d20@gB500NC@s80@a0@t0@Gl1500@w91@l1300@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Forankringsjern | Søyle | Brattvåg-Dryna armering - K-M14 B/B min.: 1300
ARMERING | 20 | B500NC | P4025 | 4 | 2750 | 11000 | 6.8 | 27.2 | 99-100 | 1500 | OK | 1*80 + 1*180 + 1*80 | BF2D@Hj10259741-01@rMC@i01@pP4025@l2750@n1@e6.78@d20@gB500NC@s80@a0@t0@Gl1500@w89@l1300@w0@C96@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Forankringsjern | Søyle | Brattvåg-Dryna armering - K-M14 B/B min.: 1300
ARMERING | 20 | B500NC | P4021 | 4 | 2250 | 9000 | 5.5 | 22.2 | NB99-16 | 1500 | OK | 1*80 + 1*180 + 1*80 | BF2D@Hj10259741-01@rMC@i01@pP4021@l2250@n1@e5.55@d20@gB500NC@s80@a0@t0@Gl1500@w91@l800@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Forankringsjern | Søyle | Brattvåg-Dryna armering - K-M14 B/B min.: 800
ARMERING | 16 | B500NC | P5050 | 11 | 2790 | 30690 | 4.4 | 48.4 | NB99-01 | 1120 | SK | 5*200 + 1*190 + 4*200 | BF2D@Hj10259741-01@rMC@i01@pP5050@l2790@n1@e4.4@d16@gB500NC@s50@a0@t0@Gl125@w180@l1120@w89@l325@w91@l1120@w180@l125@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 325; K-M10 Krok Start: 3; K-M16 C/C min.: 1120
ARMERING | 20 | B500NC | P5039 | 3 | 3000 | 9000 | 7.4 | 22.2 | 00 | 3000 | UK | 1*200 + 1*205 | BF2D@Hj10259741-01@rMC@i01@pP5039@l3000@n1@e7.4@d20@gB500NC@s0@a0@t0@Gl3000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 20 | B500NC | P5039 | 3 | 3000 | 9000 | 7.4 | 22.2 | 00 | 3000 | OK | 1*200 + 1*145 | BF2D@Hj10259741-01@rMC@i01@pP5039@l3000@n1@e7.4@d20@gB500NC@s0@a0@t0@Gl3000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 25 | B500NC | P5049 | 4 | 3105 | 12420 | 12 | 47.9 | 00 | 3105 | OK | 1*100 + 1*90 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5049@l2105@n1@e3.32@d16@gB500NC@s0@a0@t0@Gl2105@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 25 | B500NC | P5049 | 4 | 3105 | 12420 | 12 | 47.9 | 00 | 3105 | UK | 1*100 + 1*90 + 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5049@l2105@n1@e3.32@d16@gB500NC@s0@a0@t0@Gl2105@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 20 | B500NC | P3021 | 3 | 3510 | 10530 | 8.7 | 26 | 21 | 1600 | YK | 1*195 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP3021@l3515@n1@e8.66@d20@gB500NC@s80@a0@t0@Gl1600@w90@l410@w90@l1600@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1600
ARMERING | 16 | B500NC | P5040 | 17 | 4500 | 76500 | 7.1 | 120.7 | 00 | 4500 | OK | 16*200 | BF2D@Hj10259741-01@rMC@i01@pP5040@l4500@n1@e7.1@d16@gB500NC@s0@a0@t0@Gl4500@w0@C76@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5043 | 15 | 3000 | 45000 | 4.7 | 71 | 00 | 3000 | OK | 14*200 | BF2D@Hj10259741-01@rMC@i01@pP5043@l3000@n1@e4.73@d16@gB500NC@s0@a0@t0@Gl3000@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5042 | 13 | 4000 | 52000 | 6.3 | 82.1 | 00 | 4000 | UK | 12*400 | BF2D@Hj10259741-01@rMC@i01@pP5042@l4000@n1@e6.31@d16@gB500NC@s0@a0@t0@Gl4000@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5042 | 18 | 4000 | 72000 | 6.3 | 113.6 | 00 | 4000 | UK | 17*400 | BF2D@Hj10259741-01@rMC@i01@pP5042@l4000@n1@e6.31@d16@gB500NC@s0@a0@t0@Gl4000@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5042 | 29 | 4000 | 116000 | 6.3 | 183 | 00 | 4000 | OK | 28*200 | BF2D@Hj10259741-01@rMC@i01@pP5042@l4000@n1@e6.31@d16@gB500NC@s0@a0@t0@Gl4000@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5041 | 14 | 8000 | 112000 | 12.6 | 176.7 | 00 | 8000 | UK | 6*400 + 1*250 + 6*400 | BF2D@Hj10259741-01@rMC@i01@pP5041@l8000@n1@e12.62@d16@gB500NC@s0@a0@t0@Gl8000@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5040 | 26 | 4500 | 117000 | 7.1 | 184.6 | 00 | 4500 | UK | 25*400 | BF2D@Hj10259741-01@rMC@i01@pP5040@l4500@n1@e7.1@d16@gB500NC@s0@a0@t0@Gl4500@w0@C76@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P3009 | 6 | 2940 | 17640 | 4.6 | 27.8 | NB99-01 | 1300 | OK | 1*200 + 1*80 + 1*200 + 1*80 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP3009@l2940@n1@e4.64@d16@gB500NC@s50@a0@t0@Gl1300@w91@l405@w89@l1300@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 405; K-M16 C/C min.: 1300; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P5039 | 4 | 3000 | 12000 | 7.4 | 29.6 | 00 | 3000 | OK | 1*157 + 1*127 + 1*153 | BF2D@Hj10259741-01@rMC@i01@pP5039@l3000@n1@e7.4@d20@gB500NC@s0@a0@t0@Gl3000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 20 | B500NC | P5039 | 4 | 3000 | 12000 | 7.4 | 29.6 | 00 | 3000 | OK | 1*110 + 1*180 + 1*150 | BF2D@Hj10259741-01@rMC@i01@pP5039@l3000@n1@e7.4@d20@gB500NC@s0@a0@t0@Gl3000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5038 | 5 | 4260 | 21300 | 6.7 | 33.6 | 21 | 2000 | SK | 2*200 + 1*160 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP5038@l4260@n1@e6.72@d16@gB500NC@s50@a0@t0@Gl2000@w90@l330@w90@l2000@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 2000
4 x ARMERING | 20 | B500NC | P6024 | 2 | 2810 | 5620 | 6.9 | 13.9 | 21 | 1000 | v/ bolter | 1*160 | BF2D@Hj10259741-01@rMC@i01@pP6024@l2810@n1@e6.93@d20@gB500NC@s80@a0@t0@Gl1000@w90@l905@w90@l1000@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 905; K-M16 C/C min.: 1000
2 x ARMERING | 20 | B500NC | P6023 | 4 | 3420 | 13680 | 8.4 | 33.7 | 31 | 965 | v/ bolter | 1*200 + 1*370 + 1*185 | BF2D@Hj10259741-01@rMC@i01@pP6023@l3420@n1@e8.43@d20@gB500NC@s80@a0@t0@Gl265@w90@l600@w90@l965@w90@l600@w90@l965@w90@l265@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Fundament | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 600; K-M10 Krok Start: 1; K-M16 C/C min.: 965; K-M18 D/D min.: 600
8 x ARMERING | 20 | B500NC | P6021 | 3 | 2265 | 6795 | 5.6 | 16.8 | 21 | 1000 | v/ bolter | 2*225 | BF2D@Hj10259741-01@rMC@i01@pP6021@l2270@n1@e5.59@d20@gB500NC@s80@a0@t0@Gl1000@w90@l365@w90@l1000@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 365; K-M16 C/C min.: 1000
4 x ARMERING | 20 | B500NC | P6020 | 3 | 2400 | 7200 | 5.9 | 17.8 | 21 | 1000 | v/bolter | 2*185 | BF2D@Hj10259741-01@rMC@i01@pP6020@l2400@n1@e5.92@d20@gB500NC@s80@a0@t0@Gl1000@w90@l495@w90@l1000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 495; K-M16 C/C min.: 1000
3 x ARMERING | 20 | B500NC | P6015 | 8 | 3340 | 26720 | 8.2 | 66 | 21 | 1500 | v/ bolter | 1*150 + 1*120 + 1*150 + 1*120 + 1*150 + 1*120 + 1*150 | BF2D@Hj10259741-01@rMC@i01@pP6015@l3345@n1@e8.24@d20@gB500NC@s80@a0@t0@Gl1500@w90@l440@w90@l1500@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 440; K-M16 C/C min.: 1500
ARMERING | 20 | B500NC | P6022 | 2 | 4700 | 9400 | 11.6 | 23.2 | 00 | 4700 | v/ bolter | 1*340 | BF2D@Hj10259741-01@rMC@i01@pP6022@l4700@n1@e11.59@d20@gB500NC@s0@a0@t0@Gl4700@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Fundament
2 x ARMERING | 20 | B500NC | P6021 | 2 | 2265 | 4530 | 5.6 | 11.2 | 21 | 1000 | v/ bolter | 1*250 | BF2D@Hj10259741-01@rMC@i01@pP6021@l2270@n1@e5.59@d20@gB500NC@s80@a0@t0@Gl1000@w90@l365@w90@l1000@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 365; K-M16 C/C min.: 1000
2 x ARMERING | 20 | B500NC | P6021 | 2 | 2265 | 4530 | 5.6 | 11.2 | 21 | 1000 | v/ bolter | 1*225 | BF2D@Hj10259741-01@rMC@i01@pP6021@l2270@n1@e5.59@d20@gB500NC@s80@a0@t0@Gl1000@w90@l365@w90@l1000@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 365; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P6020 | 2 | 2400 | 4800 | 5.9 | 11.8 | 21 | 1000 | v/bolter | 1*220 | BF2D@Hj10259741-01@rMC@i01@pP6020@l2400@n1@e5.92@d20@gB500NC@s80@a0@t0@Gl1000@w90@l495@w90@l1000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 495; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P6020 | 2 | 2400 | 4800 | 5.9 | 11.8 | 21 | 1000 | v/bolter | 1*185 | BF2D@Hj10259741-01@rMC@i01@pP6020@l2400@n1@e5.92@d20@gB500NC@s80@a0@t0@Gl1000@w90@l495@w90@l1000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 495; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P6016 | 2 | 2700 | 5400 | 6.7 | 13.3 | 00 | 2700 | v/ bolter | 1*340 | BF2D@Hj10259741-01@rMC@i01@pP6016@l2700@n1@e6.66@d20@gB500NC@s0@a0@t0@Gl2700@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Fundament
ARMERING | 20 | B500NC | P5058 | 2 | 2060 | 4120 | 5.1 | 10.2 | 21 | 700 | SK | 1*175 | BF2D@Hj10259741-01@rMC@i01@pP5058@l2065@n1@e5.08@d20@gB500NC@s80@a0@t0@Gl700@w90@l760@w90@l700@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 1 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 760; K-M16 C/C min.: 700
ARMERING | 20 | B500NC | P6019 | 2 | 2060 | 4120 | 5.1 | 10.2 | 21 | 700 | SK | 1*135 | BF2D@Hj10259741-01@rMC@i01@pP6019@l2065@n1@e5.08@d20@gB500NC@s80@a0@t0@Gl700@w90@l760@w90@l700@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 1 | Bøyle | Fundament | Brattvåg-Dryna armering - K-M14 B/B min.: 760; K-M16 C/C min.: 700
ARMERING | 20 | B500NC | P5057 | 7 | 3710 | 25970 | 9.1 | 64.1 | 21 | 1500 | UK | 5*200 + 1*75 | BF2D@Hj10259741-01@rMC@i01@pP5057@l3715@n1@e9.15@d20@gB500NC@s80@a0@t0@Gl1500@w90@l810@w90@l1500@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 1 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 810; K-M16 C/C min.: 1500
ARMERING | 20 | B500NC | P5056 | 5 | 4210 | 21050 | 10.4 | 52 | 21 | 1500 | UK | 3*200 + 1*85 | BF2D@Hj10259741-01@rMC@i01@pP5056@l4215@n1@e10.38@d20@gB500NC@s80@a0@t0@Gl1500@w90@l1310@w90@l1500@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 1 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 1310; K-M16 C/C min.: 1500
4 x ARMERING | 20 | B500NC | P7006 | 7 | 2210 | 15470 | 5.4 | 38.2 | 21 | 1000 | SK | 6*200 | BF2D@Hj10259741-01@rMC@i01@pP7006@l2215@n1@e5.45@d20@gB500NC@s80@a0@t0@Gl1000@w90@l310@w90@l1000@w0@C89@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Brystningselement | Brattvåg-Dryna armering - K-M14 B/B min.: 310; K-M16 C/C min.: 1000
4 x ARMERING | 20 | B500NC | P7005 | 8 | 2180 | 17440 | 5.4 | 43.1 | 21 | 1000 | SK | 6*200 + 1*206 | BF2D@Hj10259741-01@rMC@i01@pP7005@l2185@n1@e5.38@d20@gB500NC@s80@a0@t0@Gl1000@w90@l280@w90@l1000@w0@C76@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Brystningselement | Brattvåg-Dryna armering - K-M14 B/B min.: 280; K-M16 C/C min.: 1000
ARMERING | 16 | B500NC | P7007 | 2 | 2140 | 4280 | 3.4 | 6.7 | 21 | 1000 | SK | 1*200 | BF2D@Hj10259741-01@rMC@i01@pP7007@l2140@n1@e3.38@d16@gB500NC@s50@a0@t0@Gl1000@w90@l210@w90@l1000@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Brystningselement | Brattvåg-Dryna armering - K-M14 B/B min.: 210; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P7002 | 4 | 2250 | 9000 | 5.5 | 22.2 | 00 | 2250 | SK | 1*70 + 1*35 + 1*70 | BF2D@Hj10259741-01@rMC@i01@pP7002@l2250@n1@e5.55@d20@gB500NC@s0@a0@t0@Gl2250@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Brystningselement
2 x ARMERING | 20 | B500NC | P7002 | 22 | 2250 | 49500 | 5.5 | 122.1 | 00 | 2250 | SK | 10*200 + 1*156 + 10*200 | BF2D@Hj10259741-01@rMC@i01@pP7002@l2250@n1@e5.55@d20@gB500NC@s0@a0@t0@Gl2250@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Brystningselement
2 x ARMERING | 20 | B500NC | P7002 | 22 | 2250 | 49500 | 5.5 | 122.1 | 00 | 2250 | SK | 10*200 + 1*150 + 10*200 | BF2D@Hj10259741-01@rMC@i01@pP7002@l2250@n1@e5.55@d20@gB500NC@s0@a0@t0@Gl2250@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Brystningselement
2 x ARMERING | 25 | B500NC | P7001 | 13 | 4715 | 61295 | 18.2 | 236.2 | 00 | 4310 | SK | 6*200 + 1*45 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP7001@l4715@n1@e18.17@d25@gB500NC@s80@a0@t0@Gl170@w180@l4310@w180@l170@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Brystningselement | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M10 Krok Start: 3
2 x ARMERING | 25 | B500NC | P7000 | 13 | 5260 | 68380 | 20.3 | 263.5 | NB99-01 | 395 | SK | 11*200 + 1*80 | BF2D@Hj10259741-01@rMC@i01@pP7000@l5260@n1@e20.27@d25@gB500NC@s125@a0@t0@Gl340@w90@l315@w89@l4110@w91@l395@w90@l340@w0@C65@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Brystningselement | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 4110; K-M10 Krok Start: 1; K-M16 C/C min.: 315
2 x ARMERING | 25 | B500NC | P7000 | 12 | 5250 | 63000 | 20.2 | 242.9 | NB99-01 | 390 | SK | 10*200 + 1*180 | BF2D@Hj10259741-01@rMC@i01@pP7000@l5260@n1@e20.27@d25@gB500NC@s125@a0@t0@Gl340@w90@l315@w89@l4110@w91@l395@w90@l340@w0@C65@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Brystningselement | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 4110; K-M10 Krok Start: 1; K-M16 C/C min.: 310
2 x ARMERING | 20 | B500NC | P5032 | 1 | 1535 | 1535 | 3.8 | 3.8 | 00 | 1140 | SK |  | BF2D@Hj10259741-01@rMC@i01@pP5032@l1540@n1@e3.79@d20@gB500NC@s80@a0@t0@Gl165@w180@l1140@w180@l165@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Trapp | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M10 Krok Start: 3; K-M33 Merknader til utførelse 1: Tilpasses bolter
ARMERING | 20 | B500NC | P5037 | 4 | 2445 | 9780 | 6 | 24.1 | 31 | 890 | SK | 1*200 + 1*550 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP5037@l2445@n1@e6.03@d20@gB500NC@s80@a0@t0@Gl265@w90@l890@w90@l185@w90@l890@w90@l185@w90@l265@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Trapp | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 185; K-M10 Krok Start: 1; K-M16 C/C min.: 890; K-M18 D/D min.: 185; K-M33 Merknader til utførelse 1: Tilpasses bolter
3 x ARMERING | 32 | B500NC | P4007 | 12 | 11805 | 141660 | 74.5 | 894.3 | 00 | 11805 | Lag 2 | 11*150 | BF2D@Hj10259741-01@rMC@i01@pP4007@l11805@n1@e74.53@d32@gB500NC@s0@a0@t0@Gl11805@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Utstøpt stålrør | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Utføres med T-hoder HRC110 eller tilsvarende
3 x ARMERING | 16 | B500NC | P4009 | 46 | 2485 | 114310 | 3.9 | 180.5 | 67 | 2490 | Lag 1 | 45*200 |  | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Utstøpt stålrør
ARMERING | 20 | B500NC | P6001 | 3 | 2910 | 8730 | 7.2 | 21.6 | 21 | 800 | OK | 1*200 + 1*135 | BF2D@Hj10259741-01@rMC@i01@pP6001@l2915@n1@e7.18@d20@gB500NC@s80@a0@t0@Gl800@w90@l1410@w90@l800@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 1410; K-M16 C/C min.: 800; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P6001 | 3 | 2910 | 8730 | 7.2 | 21.6 | 21 | 800 | UK | 1*200 + 1*85 | BF2D@Hj10259741-01@rMC@i01@pP6001@l2915@n1@e7.18@d20@gB500NC@s80@a0@t0@Gl800@w90@l1410@w90@l800@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 1410; K-M16 C/C min.: 800; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P6000 | 5 | 1910 | 9550 | 4.7 | 23.6 | 21 | 800 | UK | 3*200 + 1*155 | BF2D@Hj10259741-01@rMC@i01@pP6000@l1915@n1@e4.71@d20@gB500NC@s80@a0@t0@Gl800@w90@l410@w90@l800@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 800; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P6000 | 5 | 1910 | 9550 | 4.7 | 23.6 | 21 | 800 | OK | 3*200 + 1*205 | BF2D@Hj10259741-01@rMC@i01@pP6000@l1915@n1@e4.71@d20@gB500NC@s80@a0@t0@Gl800@w90@l410@w90@l800@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 800; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
2 x ARMERING | 25 | B500NC | P5025 | 12 | 6000 | 72000 | 23.1 | 277.6 | 21 | 2900 | SK | 5*200 + 1*130 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP5025@l6000@n1@e23.12@d25@gB500NC@s125@a0@t0@Gl2900@w90@l330@w90@l2900@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 2900
2 x ARMERING | 25 | B500NC | P5022 | 12 | 8000 | 96000 | 30.8 | 370 | 21 | 3900 | SK | 5*200 + 1*130 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP5022@l11395@n1@e17.98@d16@gB500NC@s0@a0@t0@Gl11395@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 3900
ARMERING | 20 | B500NC | P5036 | 3 | 2170 | 6510 | 5.4 | 16.1 | 21 | 1000 | UK | 1*23 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP5036@l2175@n1@e5.35@d20@gB500NC@s80@a0@t0@Gl1000@w90@l270@w90@l1000@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 270; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P5036 | 3 | 2170 | 6510 | 5.4 | 16.1 | 21 | 1000 | SK | 1*23 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP5036@l2175@n1@e5.35@d20@gB500NC@s80@a0@t0@Gl1000@w90@l270@w90@l1000@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 270; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P5035 | 2 | 3560 | 7120 | 8.8 | 17.6 | 00 | 3560 | UK | 1*209 | BF2D@Hj10259741-01@rMC@i01@pP5035@l3560@n1@e8.78@d20@gB500NC@s0@a0@t0@Gl3560@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 20 | B500NC | P5035 | 2 | 3560 | 7120 | 8.8 | 17.6 | 00 | 3560 | OK | 1*209 | BF2D@Hj10259741-01@rMC@i01@pP5035@l3560@n1@e8.78@d20@gB500NC@s0@a0@t0@Gl3560@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 20 | B500NC | P5035 | 2 | 3560 | 7120 | 8.8 | 17.6 | 00 | 3560 | UK | 1*204 | BF2D@Hj10259741-01@rMC@i01@pP5035@l3560@n1@e8.78@d20@gB500NC@s0@a0@t0@Gl3560@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 20 | B500NC | P5035 | 2 | 3560 | 7120 | 8.8 | 17.6 | 00 | 3560 | OK | 1*204 | BF2D@Hj10259741-01@rMC@i01@pP5035@l3560@n1@e8.78@d20@gB500NC@s0@a0@t0@Gl3560@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
2 x ARMERING | 20 | B500NC | P5030 | 1 | 1705 | 1705 | 4.2 | 4.2 | 00 | 1310 | SK |  | BF2D@Hj10259741-01@rMC@i01@pP5030@l1710@n1@e4.21@d20@gB500NC@s80@a0@t0@Gl165@w180@l1310@w180@l165@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Trapp | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M10 Krok Start: 3; K-M33 Merknader til utførelse 1: Tilpasses bolter
ARMERING | 20 | B500NC | P5034 | 1 | 1720 | 1720 | 4.2 | 4.2 | 21 | 230 | SK |  | BF2D@Hj10259741-01@rMC@i01@pP5034@l1720@n1@e4.24@d20@gB500NC@s80@a0@t0@Gl165@w180@l230@w90@l950@w90@l230@w180@l165@w0@C92@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Trapp | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 950; K-M10 Krok Start: 3; K-M16 C/C min.: 230; K-M33 Merknader til utførelse 1: Tilpasses bolter
ARMERING | 20 | B500NC | P5033 | 4 | 1660 | 6640 | 4.1 | 16.4 | 99-100 | 1225 | SK | 1*150 + 1*600 + 1*125 | BF2D@Hj10259741-01@rMC@i01@pP5033@l1660@n1@e4.09@d20@gB500NC@s80@a0@t0@Gl1230@w89.5@l260@w90@l265@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Trapp | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 260; K-M33 Merknader til utførelse 1: Tilpasses bolter
ARMERING | 20 | B500NC | P5031 | 4 | 2045 | 8180 | 5 | 20.2 | 31 | 690 | SK | 1*250 + 1*300 + 1*250 | BF2D@Hj10259741-01@rMC@i01@pP5031@l2045@n1@e5.04@d20@gB500NC@s80@a0@t0@Gl265@w90@l690@w90@l185@w90@l690@w90@l185@w90@l265@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Trapp | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 185; K-M10 Krok Start: 1; K-M16 C/C min.: 690; K-M18 D/D min.: 185; K-M33 Merknader til utførelse 1: Tilpasses bolter
3 x ARMERING | 20 | B500NC | P4004 | 1 | 4020 | 4020 | 9.9 | 9.9 | 00 | 4020 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pP4004@l4020@n1@e9.91@d20@gB500NC@s0@a0@t0@Gl4020@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Søyle
2 x ARMERING | 20 | B500NC | P4004 | 1 | 4025 | 4025 | 9.9 | 9.9 | 00 | 4025 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pP4004@l4020@n1@e9.91@d20@gB500NC@s0@a0@t0@Gl4020@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Søyle
2 x ARMERING | 20 | B500NC | P4015 | 1 | 4025 | 4025 | 9.9 | 9.9 | 00 | 4025 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pP4015@l4025@n1@e9.93@d20@gB500NC@s0@a0@t0@Gl4025@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Søyle
3 x ARMERING | 20 | B500NC | P4015 | 1 | 4030 | 4030 | 9.9 | 9.9 | 00 | 4030 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pP4015@l4025@n1@e9.93@d20@gB500NC@s0@a0@t0@Gl4025@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Søyle
ARMERING | 20 | B500NC | P5029 | 7 | 2705 | 18935 | 6.7 | 46.8 | 99-101 | 390 | SK | 3*200 + 1*175 + 2*200 | BF2D@Hj10259741-01@rMC@i01@pP5029@l2715@n1@e6.7@d20@gB500NC@s80@a0@t0@Gl265@w90@l540@w32@l1370@w58@l390@w90@l265@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Trapp | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 1325; K-M10 Krok Start: 1; K-M16 C/C min.: 580; K-M33 Merknader til utførelse 1: Tilpasses bolter
ARMERING | 20 | B500NC | P5028 | 7 | 2245 | 15715 | 5.5 | 38.8 | 00 | 1845 | SK | 3*200 + 1*125 + 2*200 | BF2D@Hj10259741-01@rMC@i01@pP5028@l2245@n1@e5.54@d20@gB500NC@s80@a0@t0@Gl165@w180@l1845@w180@l165@w0@C96@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Trapp | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M10 Krok Start: 3; K-M33 Merknader til utførelse 1: Tilpasses bolter
ARMERING | 20 | B500NC | P3013 | 17 | 3260 | 55420 | 8 | 136.9 | 21 | 1500 | SK | 1*47 + 15*200 | BF2D@Hj10259741-01@rMC@i01@pP3013@l3265@n1@e8.04@d20@gB500NC@s80@a0@t0@Gl1500@w90@l360@w90@l1500@w0@C76@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1500; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3119 | 1 | 2430 | 2430 | 6 | 6 | 00 | 2430 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3119@l2430@n1@e5.99@d20@gB500NC@s0@a0@t0@Gl2430@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3171 | 1 | 2510 | 2510 | 6.2 | 6.2 | 00 | 2510 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3171@l2510@n1@e6.19@d20@gB500NC@s0@a0@t0@Gl2510@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3165 | 1 | 2585 | 2585 | 6.4 | 6.4 | 00 | 2585 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3165@l2585@n1@e6.38@d20@gB500NC@s0@a0@t0@Gl2585@w0@C83@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3164 | 1 | 2660 | 2660 | 6.6 | 6.6 | 00 | 2660 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3164@l2660@n1@e6.56@d20@gB500NC@s0@a0@t0@Gl2660@w0@C96@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
3 x Løpemeter | 20 | B500NC | Lm3054 | 1 | 2740 | 2740 | 6.8 | 6.8 | 00 | 2740 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3054@l2740@n1@e6.76@d20@gB500NC@s0@a0@t0@Gl2740@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3161 | 1 | 2815 | 2815 | 6.9 | 6.9 | 00 | 2815 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3161@l2815@n1@e6.94@d20@gB500NC@s0@a0@t0@Gl2815@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3159 | 1 | 2890 | 2890 | 7.1 | 7.1 | 00 | 2890 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3159@l2890@n1@e7.13@d20@gB500NC@s0@a0@t0@Gl2890@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
3 x Løpemeter | 20 | B500NC | Lm3128 | 1 | 2970 | 2970 | 7.3 | 7.3 | 00 | 2970 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3128@l2970@n1@e7.32@d20@gB500NC@s0@a0@t0@Gl2970@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
3 x Løpemeter | 20 | B500NC | Lm3147 | 1 | 3020 | 3020 | 7.4 | 7.4 | 00 | 3020 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3147@l3020@n1@e7.45@d20@gB500NC@s0@a0@t0@Gl3020@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3061 | 1 | 3005 | 3005 | 7.4 | 7.4 | 00 | 3005 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3061@l3005@n1@e7.41@d20@gB500NC@s0@a0@t0@Gl3005@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3147 | 1 | 3010 | 3010 | 7.4 | 7.4 | 00 | 3010 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3147@l3020@n1@e7.45@d20@gB500NC@s0@a0@t0@Gl3020@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
4 x Løpemeter | 20 | B500NC | Lm3147 | 1 | 3015 | 3015 | 7.4 | 7.4 | 00 | 3015 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3147@l3020@n1@e7.45@d20@gB500NC@s0@a0@t0@Gl3020@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3166 | 12 | 2360 | 28320 | 5.8 | 69.8 | 00 | 2360 | Lag 2 | 11*200 | BF2D@Hj10259741-01@rMC@i01@pLm3166@l2360@n1@e5.82@d20@gB500NC@s0@a0@t0@Gl2360@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P5027 | 7 | 3140 | 21980 | 7.7 | 54.2 | 11 | 1705 | SK | 3*200 + 1*125 + 2*200 | BF2D@Hj10259741-01@rMC@i01@pP5027@l3150@n1@e7.77@d20@gB500NC@s80@a0@t0@Gl165@w180@l1090@w90@l1705@w180@l165@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Trapp | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 1080; K-M10 Krok Start: 3; K-M33 Merknader til utførelse 1: Tilpasses bolter
ARMERING | 20 | B500NC | P4023 | 2 | 2450 | 4900 | 6 | 12.1 | 11 | 1500 | OK | 1*280 | BF2D@Hj10259741-01@rMC@i01@pP4023@l2450@n1@e6.04@d20@gB500NC@s80@a0@t0@Gl1500@w90@l1000@w0@C91@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Forankringsjern | Søyle | Brattvåg-Dryna armering - K-M14 B/B min.: 1000
ARMERING | 20 | B500NC | P4022 | 2 | 2250 | 4500 | 5.5 | 11.1 | 11 | 1500 | OK | 1*200 | BF2D@Hj10259741-01@rMC@i01@pP4022@l2250@n1@e5.55@d20@gB500NC@s80@a0@t0@Gl1500@w90@l800@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Forankringsjern | Søyle | Brattvåg-Dryna armering - K-M14 B/B min.: 800
ARMERING | 20 | B500NC | P4028 | 4 | 2150 | 8600 | 5.3 | 21.2 | NB99-16 | 1500 | OK | 1*80 + 1*220 + 1*110 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Forankringsjern | Søyle | Brattvåg-Dryna armering - K-M14 B/B min.: 700
ARMERING | 20 | B500NC | P7002 | 4 | 2250 | 9000 | 5.5 | 22.2 | 00 | 2250 | SK | 1*70 + 1*35 + 1*70 | BF2D@Hj10259741-01@rMC@i01@pP7002@l2250@n1@e5.55@d20@gB500NC@s0@a0@t0@Gl2250@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Brystningselement
ARMERING | 20 | B500NC | P5016 | 9 | 2230 | 20070 | 5.5 | 49.6 | 21 | 1000 | SK | 4*200 + 1*195 + 3*200 | BF2D@Hj10259741-01@rMC@i01@pP5016@l2235@n1@e5.5@d20@gB500NC@s80@a0@t0@Gl1000@w90@l330@w90@l1000@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 1000
ARMERING | 16 | B500NC | P5015 | 47 | 1860 | 87420 | 2.9 | 137.9 | 21 | 800 | SK | 23*200 + 1*40 + 22*200 | BF2D@Hj10259741-01@rMC@i01@pP5015@l1860@n1@e2.94@d16@gB500NC@s50@a0@t0@Gl800@w90@l330@w90@l800@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 800
ARMERING | 16 | B500NC | P5000 | 40 | 5810 | 232400 | 9.2 | 366.9 | 00 | 5810 | OK | 19*200 + 1*190 + 19*200 | BF2D@Hj10259741-01@rMC@i01@pP5000@l5810@n1@e9.17@d16@gB500NC@s0@a0@t0@Gl5810@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 20 | B500NC | P5001 | 10 | 5810 | 58100 | 14.3 | 143.3 | 00 | 5810 | UK | 4*200 + 1*60 + 4*200 | BF2D@Hj10259741-01@rMC@i01@pP5001@l5810@n1@e14.33@d20@gB500NC@s0@a0@t0@Gl5810@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Kaidekke
ARMERING | 20 | B500NC | P3014 | 3 | 2270 | 6810 | 5.6 | 16.8 | 21 | 1000 | SK | 1*135 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP3014@l2275@n1@e5.6@d20@gB500NC@s80@a0@t0@Gl1000@w90@l370@w90@l1000@w0@C69@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 370; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3010 | 3 | 2260 | 6780 | 5.6 | 16.7 | 21 | 1000 | UK | 1*127 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP3010@l2265@n1@e5.57@d20@gB500NC@s80@a0@t0@Gl1000@w90@l360@w90@l1000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 6 | 2310 | 13860 | 5.7 | 34.2 | 21 | 1000 | UK | 1*139 + 4*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3010 | 4 | 2260 | 9040 | 5.6 | 22.3 | 21 | 1000 | UK | 1*95 + 2*200 | BF2D@Hj10259741-01@rMC@i01@pP3010@l2265@n1@e5.57@d20@gB500NC@s80@a0@t0@Gl1000@w90@l360@w90@l1000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 20 | 2310 | 46200 | 5.7 | 114.2 | 21 | 1000 | UK | 1*109 + 18*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 1 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 8 | 2310 | 18480 | 5.7 | 45.7 | 21 | 1000 | UK | 1*146 + 6*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3158 | 1 | 2265 | 2265 | 5.6 | 5.6 | 00 | 2265 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3158@l2265@n1@e5.59@d20@gB500NC@s0@a0@t0@Gl2265@w0@C89@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3157 | 1 | 2330 | 2330 | 5.7 | 5.7 | 00 | 2330 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3157@l2330@n1@e5.75@d20@gB500NC@s0@a0@t0@Gl2330@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3013 | 16 | 3260 | 52160 | 8 | 128.8 | 21 | 1500 | SK | 15*199 | BF2D@Hj10259741-01@rMC@i01@pP3013@l3265@n1@e8.04@d20@gB500NC@s80@a0@t0@Gl1500@w90@l360@w90@l1500@w0@C76@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1500; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3012 | 2 | 2710 | 5420 | 6.7 | 13.4 | 21 | 1200 | OK | 1*215 | BF2D@Hj10259741-01@rMC@i01@pP3012@l2715@n1@e6.68@d20@gB500NC@s80@a0@t0@Gl1200@w90@l410@w90@l1200@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1200; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 31 | 2310 | 71610 | 5.7 | 177 | 21 | 1000 | OK | 1*84 + 29*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3010 | 12 | 2260 | 27120 | 5.6 | 67 | 21 | 1000 | SK | 1*63 + 10*200 | BF2D@Hj10259741-01@rMC@i01@pP3010@l2265@n1@e5.57@d20@gB500NC@s80@a0@t0@Gl1000@w90@l360@w90@l1000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3003 | 80 | 3315 | 265200 | 8.2 | 654.2 | NB99-01 | 1500 | OK | 1*217 + 78*200 | BF2D@Hj10259741-01@rMC@i01@pP3003@l3315@n1@e8.18@d20@gB500NC@s80@a0@t0@Gl1500@w91@l405@w89@l1500@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 405; K-M16 C/C min.: 1500; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3008 | 16 | 3270 | 52320 | 8.1 | 129.2 | 21 | 1500 | SK | 1*142 + 14*200 | BF2D@Hj10259741-01@rMC@i01@pP3008@l3275@n1@e8.06@d20@gB500NC@s80@a0@t0@Gl1500@w90@l370@w90@l1500@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 370; K-M16 C/C min.: 1500; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3010 | 3 | 2260 | 6780 | 5.6 | 16.7 | 21 | 1000 | UK | 1*216 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP3010@l2265@n1@e5.57@d20@gB500NC@s80@a0@t0@Gl1000@w90@l360@w90@l1000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3001 | 2 | 3310 | 6620 | 8.2 | 16.3 | 21 | 1500 | OK | 1*215 | BF2D@Hj10259741-01@rMC@i01@pP3001@l3315@n1@e8.16@d20@gB500NC@s80@a0@t0@Gl1500@w90@l410@w90@l1500@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1500; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 4 | 2310 | 9240 | 5.7 | 22.8 | 21 | 1000 | UK | 1*135 + 2*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 1 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3170 | 1 | 3530 | 3530 | 8.7 | 8.7 | 00 | 3530 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3170@l3530@n1@e8.71@d20@gB500NC@s0@a0@t0@Gl3530@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3074 | 1 | 3085 | 3085 | 7.6 | 7.6 | 00 | 3085 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3074@l3085@n1@e7.61@d20@gB500NC@s0@a0@t0@Gl3085@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3073 | 1 | 3080 | 3080 | 7.6 | 7.6 | 00 | 3080 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3073@l3080@n1@e7.6@d20@gB500NC@s0@a0@t0@Gl3080@w0@C91@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
Løpemeter | 20 | B500NC | Lm3075 | 1 | 3090 | 3090 | 7.6 | 7.6 | 00 | 3090 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3075@l3090@n1@e7.62@d20@gB500NC@s0@a0@t0@Gl3090@w0@C69@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3072 | 1 | 3075 | 3075 | 7.6 | 7.6 | 00 | 3075 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3072@l3075@n1@e7.58@d20@gB500NC@s0@a0@t0@Gl3075@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3071 | 1 | 3070 | 3070 | 7.6 | 7.6 | 00 | 3070 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3071@l3070@n1@e7.57@d20@gB500NC@s0@a0@t0@Gl3070@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3010 | 13 | 2260 | 29380 | 5.6 | 72.6 | 21 | 1000 | SK | 1*103 + 11*200 | BF2D@Hj10259741-01@rMC@i01@pP3010@l2265@n1@e5.57@d20@gB500NC@s80@a0@t0@Gl1000@w90@l360@w90@l1000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 10 | 2310 | 23100 | 5.7 | 57.1 | 21 | 1000 | OK | 1*110 + 8*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 9 | 2310 | 20790 | 5.7 | 51.4 | 21 | 1000 | SK | 1*210 + 7*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3046 | 1 | 1985 | 1985 | 4.9 | 4.9 | 00 | 1985 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3046@l1985@n1@e4.9@d20@gB500NC@s0@a0@t0@Gl1985@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3163 | 1 | 1460 | 1460 | 3.6 | 3.6 | 00 | 1460 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3163@l1460@n1@e3.6@d20@gB500NC@s0@a0@t0@Gl1460@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3162 | 1 | 940 | 940 | 2.3 | 2.3 | 00 | 940 | Lag 2 |  | BF2D@Hj10259741-01@rMC@i01@pLm3162@l940@n1@e2.32@d20@gB500NC@s0@a0@t0@Gl940@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3004 | 30 | 1210 | 36300 | 3 | 89.5 | 00 | 1210 | SK | 28*200 + 1*165 | BF2D@Hj10259741-01@rMC@i01@pP3004@l1210@n1@e2.98@d20@gB500NC@s0@a0@t0@Gl1210@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3004 | 30 | 1210 | 36300 | 3 | 89.5 | 00 | 1210 | SK | 1*165 + 28*200 | BF2D@Hj10259741-01@rMC@i01@pP3004@l1210@n1@e2.98@d20@gB500NC@s0@a0@t0@Gl1210@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3010 | 7 | 2260 | 15820 | 5.6 | 39.1 | 21 | 1000 | SK | 1*190 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP3010@l2265@n1@e5.57@d20@gB500NC@s80@a0@t0@Gl1000@w90@l360@w90@l1000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P3010 | 7 | 2260 | 15820 | 5.6 | 39.1 | 21 | 1000 | SK | 1*137 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP3010@l2265@n1@e5.57@d20@gB500NC@s80@a0@t0@Gl1000@w90@l360@w90@l1000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P3002 | 7 | 5810 | 40670 | 14.3 | 100.4 | 00 | 5810 | SK | 1*73 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP3002@l5815@n1@e14.33@d20@gB500NC@s0@a0@t0@Gl5815@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3002 | 7 | 5810 | 40670 | 14.3 | 100.4 | 00 | 5810 | SK | 1*73 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP3002@l5815@n1@e14.33@d20@gB500NC@s0@a0@t0@Gl5815@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg
ARMERING | 20 | B500NC | P3001 | 30 | 3310 | 99300 | 8.2 | 245.2 | 21 | 1500 | OK | 1*136 + 28*200 | BF2D@Hj10259741-01@rMC@i01@pP3001@l3315@n1@e8.16@d20@gB500NC@s80@a0@t0@Gl1500@w90@l410@w90@l1500@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1500
ARMERING | 20 | B500NC | P3000 | 30 | 1925 | 57750 | 4.7 | 142.6 | 99 |  | UK | 1*190 + 28*200 | BF2D@Hj10259741-01@rMC@i01@pP3000@l1925@n1@e4.75@d20@gB500NC@s50@a0@t0@Gl800@w90@l410@w90@l800@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3156 | 1 | 2400 | 2400 | 5.9 | 5.9 | 00 | 2400 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3156@l2400@n1@e5.92@d20@gB500NC@s0@a0@t0@Gl2400@w0@C80@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3155 | 1 | 2470 | 2470 | 6.1 | 6.1 | 00 | 2470 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3155@l2470@n1@e6.09@d20@gB500NC@s0@a0@t0@Gl2470@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3154 | 1 | 2535 | 2535 | 6.3 | 6.3 | 00 | 2535 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3154@l2535@n1@e6.25@d20@gB500NC@s0@a0@t0@Gl2535@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3153 | 1 | 2605 | 2605 | 6.4 | 6.4 | 00 | 2605 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3153@l2605@n1@e6.42@d20@gB500NC@s0@a0@t0@Gl2605@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3152 | 1 | 2725 | 2725 | 6.7 | 6.7 | 00 | 2725 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3152@l2730@n1@e6.72@d20@gB500NC@s0@a0@t0@Gl2730@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3151 | 1 | 2930 | 2930 | 7.2 | 7.2 | 00 | 2930 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3151@l2930@n1@e7.23@d20@gB500NC@s0@a0@t0@Gl2930@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3150 | 1 | 2950 | 2950 | 7.3 | 7.3 | 00 | 2950 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3150@l2950@n1@e7.28@d20@gB500NC@s0@a0@t0@Gl2950@w0@C65@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
3 x Løpemeter | 20 | B500NC | Lm3149 | 1 | 2975 | 2975 | 7.3 | 7.3 | 00 | 2975 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3149@l2975@n1@e7.34@d20@gB500NC@s0@a0@t0@Gl2975@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
3 x Løpemeter | 20 | B500NC | Lm3148 | 1 | 2995 | 2995 | 7.4 | 7.4 | 00 | 2995 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3148@l2995@n1@e7.39@d20@gB500NC@s0@a0@t0@Gl2995@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3146 | 1 | 3300 | 3300 | 8.1 | 8.1 | 00 | 3300 | Lag 1 |  | BF2D@Hj10259741-01@rMC@i01@pLm3146@l3300@n1@e8.14@d20@gB500NC@s0@a0@t0@Gl3300@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
2 x Løpemeter | 20 | B500NC | Lm3144 | 7 | 3615 | 25305 | 8.9 | 62.4 | 00 | 3615 | Lag 1 | 6*200 | BF2D@Hj10259741-01@rMC@i01@pLm3144@l3615@n1@e8.92@d20@gB500NC@s0@a0@t0@Gl3615@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: sentravstand 200; K-M34 Merknader til utførelse 2: Tilpasses bergoverflate
