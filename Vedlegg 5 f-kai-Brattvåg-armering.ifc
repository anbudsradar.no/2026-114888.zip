Properties of the parts of a building model (IFC2X3), part 1 of 4

# File
Description: ViewDefinition[CoordinationView_V2.0], ExchangeRequirement[Structural, SurfaceGeometry], Option [GridExport:Off], Option [Assemblies:Off], Option [Bolts:Off], Option [Rebars:Off], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:-1], Option [ViewColors:On], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: f-kai-Brattvåg-armering.ifc
Time: 2026-09-10T07:20:01
Author: MCD\anls
Organization: Structural Designer
Written by: IFC Parser
Made in: Tekla Structures 2024 Service Pack 13, IFC Export Version: 4.0.0.0 Apr 21 2026

# IfcSite, Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcReinforcingBar (1147)
In: Undefined
CrossSectionArea: 0 m2
Name | NominalDiameter (mm) = K-M03 Diameter | Material = K-M02 Kvalitet | K-M00 Pos. | K-M01 Antall | K-M04 Korrigert lengde min. | K-M06 Total lengde (m) | K-M07 Vekt pr. stk./Vekt pr. stk. min.(kg) | K-M08 Total vekt (kg) | K-M09 Form | K-M12 A/A min. | K-M29 Plassering | K-M30 Senteravstand | K-M32 BVBS enkeltjern | A04 Status MMI | A05 Link til notater | A06 Link til beskrivelser | A07 Link til tegninger | A09 Revisjonsdato | A10 Revisjonsmerknad | A00 Objektnavn = A01 Objektkode V440 = A02 Objektkode V770 = A03 Spesiell beskrivelse | A08 Revisjon | K-M28 Armeringslag | K-M31 Konstruksjonsdel
6 x Armering | 16 | B500NC | P6009 | 19 | 2950 | 56050 | 4.7 | 88.6 | 11 | 2000 | UK | 18*150 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 840
6 x Armering | 16 | B500NC | P6009 | 19 | 2950 | 56050 | 4.7 | 88.6 | 11 | 2000 | UK | 17*150 + 1*110 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 840
12 x Armering | 16 | B500NC | P6011 | 3 | 3965 | 11895 | 6.3 | 18.8 | 11 | 2000 | SK | 1*150 + 1*114 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M14 B/B min.: 2000
12 x Armering | 16 | B500NC | P6011 | 3 | 3965 | 11895 | 6.3 | 18.8 | 11 | 2000 | SK | 1*150 + 1*164 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M14 B/B min.: 2000
3 x Armering | 16 | B500NC | P6010 | 19 | 2920 | 55480 | 4.6 | 87.7 | 11 | 2000 | UK | 17*150 + 1*110 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 810
3 x Armering | 16 | B500NC | P6010 | 19 | 2920 | 55480 | 4.6 | 87.7 | 11 | 2000 | UK | 18*150 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 810
10 x Armering | 16 | B500NC | P6026 | 6 | 2570 | 15420 | 4.1 | 24.4 | 21 | 995 | UK | 1*100 + 1*210 + 1*60 + 1*200 + 1*80 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 360; K-M10 Krok Start: 3; K-M16 C/C min.: 995
6 x Armering | 16 | B500NC | P6029 | 3 | 3020 | 9060 | 4.8 | 14.3 | 21 | 1215 | UK | 1*280 + 1*300 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 360; K-M10 Krok Start: 3; K-M16 C/C min.: 1215
6 x Armering | 16 | B500NC | P6030 | 6 | 2190 | 13140 | 3.5 | 20.8 | 21 | 800 | UK | 1*50 + 1*200 + 1*80 + 1*200 + 1*50 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 360; K-M10 Krok Start: 3; K-M16 C/C min.: 800
3 x Armering | 16 | B500NC | P6010 | 20 | 2920 | 58400 | 4.6 | 92.3 | 11 | 2000 | UK | 18*150 + 1*110 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 810
3 x Armering | 16 | B500NC | P6010 | 20 | 2920 | 58400 | 4.6 | 92.3 | 11 | 2000 | UK | 19*150 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 810
4 x ARMERING | 20 | B500NC | P6024 | 2 | 2810 | 5620 | 6.9 | 13.9 | 21 | 1000 | v/ bolter | 1*160 | BF2D@Hj10259741-01@rMC@i01@pP6024@l2810@n1@e6.93@d20@gB500NC@s80@a0@t0@Gl1000@w90@l905@w90@l1000@w0@C75@ | Brattvåg-Dryna armering - K-M14 B/B min.: 905; K-M16 C/C min.: 1000
2 x ARMERING | 20 | B500NC | P6023 | 4 | 3420 | 13680 | 8.4 | 33.7 | 31 | 965 | v/ bolter | 1*200 + 1*370 + 1*185 | BF2D@Hj10259741-01@rMC@i01@pP6023@l3420@n1@e8.43@d20@gB500NC@s80@a0@t0@Gl265@w90@l600@w90@l965@w90@l600@w90@l965@w90@l265@w0@C95@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 600; K-M10 Krok Start: 1; K-M16 C/C min.: 965; K-M18 D/D min.: 600
4 x ARMERING | 20 | B500NC | P6021 | 2 | 2265 | 4530 | 5.6 | 11.2 | 21 | 1000 | v/ bolter | 1*250 | BF2D@Hj10259741-01@rMC@i01@pP6021@l2270@n1@e5.59@d20@gB500NC@s80@a0@t0@Gl1000@w90@l365@w90@l1000@w0@C77@ | Brattvåg-Dryna armering - K-M14 B/B min.: 365; K-M16 C/C min.: 1000
4 x ARMERING | 20 | B500NC | P6021 | 2 | 2265 | 4530 | 5.6 | 11.2 | 21 | 1000 | v/ bolter | 1*225 | BF2D@Hj10259741-01@rMC@i01@pP6021@l2270@n1@e5.59@d20@gB500NC@s80@a0@t0@Gl1000@w90@l365@w90@l1000@w0@C77@ | Brattvåg-Dryna armering - K-M14 B/B min.: 365; K-M16 C/C min.: 1000
2 x ARMERING | 20 | B500NC | P6020 | 2 | 2400 | 4800 | 5.9 | 11.8 | 21 | 1000 | v/bolter | 1*220 | BF2D@Hj10259741-01@rMC@i01@pP6020@l2400@n1@e5.92@d20@gB500NC@s80@a0@t0@Gl1000@w90@l495@w90@l1000@w0@C82@ | Brattvåg-Dryna armering - K-M14 B/B min.: 495; K-M16 C/C min.: 1000
2 x ARMERING | 20 | B500NC | P6020 | 2 | 2400 | 4800 | 5.9 | 11.8 | 21 | 1000 | v/bolter | 1*185 | BF2D@Hj10259741-01@rMC@i01@pP6020@l2400@n1@e5.92@d20@gB500NC@s80@a0@t0@Gl1000@w90@l495@w90@l1000@w0@C82@ | Brattvåg-Dryna armering - K-M14 B/B min.: 495; K-M16 C/C min.: 1000
2 x ARMERING | 20 | B500NC | P6016 | 2 | 2700 | 5400 | 6.7 | 13.3 | 00 | 2700 | v/ bolter | 1*340 | BF2D@Hj10259741-01@rMC@i01@pP6016@l2700@n1@e6.66@d20@gB500NC@s0@a0@t0@Gl2700@w0@C83@
2 x ARMERING | 20 | B500NC | P6015 | 8 | 3340 | 26720 | 8.2 | 66 | 21 | 1500 | v/ bolter | 1*150 + 1*120 + 1*150 + 1*120 + 1*150 + 1*120 + 1*150 | BF2D@Hj10259741-01@rMC@i01@pP6015@l3345@n1@e8.24@d20@gB500NC@s80@a0@t0@Gl1500@w90@l440@w90@l1500@w0@C71@ | Brattvåg-Dryna armering - K-M14 B/B min.: 440; K-M16 C/C min.: 1500
4 x ARMERING | 16 | B500NC | P6004 | 1 | 3880 | 3880 | 6.1 | 6.1 | 21 | 1800 | UK |  | BF2D@Hj10259741-01@rMC@i01@pP6004@l3750@n1@e5.92@d16@gB500NC@s50@a0@t0@Gl1800@w90@l220@w90@l1800@w0@C67@ | Brattvåg-Dryna armering - K-M14 B/B min.: 350; K-M16 C/C min.: 1800
2 x ARMERING | 16 | B500NC | P6005 | 19 | 2320 | 44080 | 3.7 | 69.7 | 21 | 1000 | SK | 17*150 + 1*130 | BF2D@Hj10259741-01@rMC@i01@pP6005@l2190@n1@e3.46@d16@gB500NC@s50@a0@t0@Gl1000@w90@l260@w90@l1000@w0@C84@ | Brattvåg-Dryna armering - K-M14 B/B min.: 390; K-M16 C/C min.: 1000
2 x ARMERING | 16 | B500NC | P6003 | 7 | 6290 | 44030 | 9.9 | 69.5 | 21 | 1800 | SK | 5*150 + 1*85 | BF2D@Hj10259741-01@rMC@i01@pP6003@l6290@n1@e9.93@d16@gB500NC@s50@a0@t0@Gl1800@w90@l2760@w90@l1800@w0@C66@ | Brattvåg-Dryna armering - K-M14 B/B min.: 2760; K-M16 C/C min.: 1800
2 x ARMERING | 16 | B500NC | P6003 | 7 | 6290 | 44030 | 9.9 | 69.5 | 21 | 1800 | SK | 5*150 + 1*45 | BF2D@Hj10259741-01@rMC@i01@pP6003@l6290@n1@e9.93@d16@gB500NC@s50@a0@t0@Gl1800@w90@l2760@w90@l1800@w0@C66@ | Brattvåg-Dryna armering - K-M14 B/B min.: 2760; K-M16 C/C min.: 1800
2 x ARMERING | 16 | B500NC | P6028 | 20 | 4740 | 94800 | 7.5 | 149.6 | 21 | 1000 | OK | 18*150 + 1*40 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M14 B/B min.: 2810; K-M16 C/C min.: 1000
2 x ARMERING | 16 | B500NC | P6002 | 19 | 5340 | 101460 | 8.4 | 160.1 | 21 | 1300 | OK | 18*150 | BF2D@Hj10259741-01@rMC@i01@pP6002@l5340@n1@e8.43@d16@gB500NC@s50@a0@t0@Gl1300@w90@l2810@w90@l1300@w0@C92@ | Brattvåg-Dryna armering - K-M14 B/B min.: 2810; K-M16 C/C min.: 1300
4 x Armering | 16 | B500NC | P6027 | 3 | 3400 | 10200 | 5.4 | 16.1 | 21 | 1410 | UK | 1*280 + 1*300 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 360; K-M10 Krok Start: 3; K-M16 C/C min.: 1410
4 x Armering | 16 | B500NC | P6026 | 6 | 2570 | 15420 | 4.1 | 24.4 | 21 | 995 | UK | 1*50 + 1*200 + 1*80 + 1*200 + 1*50 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 360; K-M10 Krok Start: 3; K-M16 C/C min.: 995
Armering | 16 | B500NC | P6014 | 20 | 5790 | 115800 | 9.1 | 182.7 | 00 | 5790 | UK | 18*150 + 1*40 | BVBS does not existC74@
Armering | 16 | B500NC | P6025 | 39 | 2770 | 108030 | 4.4 | 170.5 | 00 | 2770 | UK | 38*150 | BVBS does not existC74@
3 x Armering | 16 | B500NC | P6007 | 4 | 5700 | 22800 | 9 | 36 | 00 | 5700 | UK | 1*155 + 2*150 | BF2D@Hj10259741-01@rMC@i01@pP6007@l5700@n1@e9@d16@gB500NC@s0@a0@t0@Gl5700@w0@C95@
Armering | 16 | B500NC | P6011 | 7 | 3965 | 27755 | 6.3 | 43.8 | 11 | 2000 | SK | 5*150 + 1*55 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M14 B/B min.: 2000
3 x Armering | 16 | B500NC | P6011 | 7 | 3965 | 27755 | 6.3 | 43.8 | 11 | 2000 | SK | 5*150 + 1*105 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M14 B/B min.: 2000
2 x Armering | 16 | B500NC | P6011 | 4 | 3965 | 15860 | 6.3 | 25 | 11 | 2000 | SK | 2*150 + 1*155 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M14 B/B min.: 2000
6 x Armering | 16 | B500NC | P6011 | 5 | 3965 | 19825 | 6.3 | 31.3 | 11 | 2000 | SK | 3*150 + 1*55 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M14 B/B min.: 2000
Armering | 16 | B500NC | P6018 | 39 | 3040 | 118560 | 4.8 | 187.4 | 11 | 2000 | UK | 38*150 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 935
Armering | 16 | B500NC | P6018 | 39 | 3040 | 118560 | 4.8 | 187.4 | 11 | 2000 | UK | 37*150 + 1*110 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 935
Armering | 16 | B500NC | P6014 | 19 | 5790 | 110010 | 9.1 | 173.6 | 00 | 5790 | UK | 17*150 + 1*110 | BVBS does not existC74@
2 x Armering | 16 | B500NC | P6017 | 19 | 2990 | 56810 | 4.7 | 89.8 | 11 | 2000 | UK | 18*150 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 885
Armering | 16 | B500NC | P6014 | 20 | 5790 | 115800 | 9.1 | 182.7 | 00 | 5790 | UK | 19*150 | BVBS does not existC74@
Armering | 16 | B500NC | P6013 | 19 | 3110 | 59090 | 4.9 | 93.4 | 11 | 2000 | UK | 18*150 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 1005
Armering | 16 | B500NC | P6013 | 19 | 3110 | 59090 | 4.9 | 93.4 | 11 | 2000 | UK | 17*150 + 1*110 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 1005
2 x Armering | 16 | B500NC | P6012 | 39 | 3140 | 122460 | 5 | 193.5 | 11 | 2000 | UK | 38*150 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 1035
2 x Armering | 16 | B500NC | P6012 | 39 | 3140 | 122460 | 5 | 193.5 | 11 | 2000 | UK | 37*150 + 1*110 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 1035
Armering | 16 | B500NC | P6014 | 20 | 5790 | 115800 | 9.1 | 182.7 | 00 | 5790 | UK | 18*150 + 1*110 | BVBS does not existC74@
2 x Armering | 16 | B500NC | P6013 | 20 | 3110 | 62200 | 4.9 | 98.3 | 11 | 2000 | UK | 19*150 | BVBS does not existC74@ | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 1005
ARMERING | 20 | B500NC | P8056 | 11 | 2105 | 23155 | 5.2 | 57.2 | 21 | 1000 |  | 5*200 + 1*218 + 4*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 205; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P8056 | 5 | 2105 | 10525 | 5.2 | 26 | 21 | 1000 |  | 2*200 + 1*94 + 1*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 205; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P8058 | 11 | 2020 | 22220 | 5 | 54.9 | NB99-01 | 970 |  | 5*200 + 1*87 + 4*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 185; K-M16 C/C min.: 910
ARMERING | 20 | B500NC | P8056 | 21 | 2105 | 44205 | 5.2 | 109.3 | 21 | 1000 |  | 20*192 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 205; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P8057 | 39 | 1990 | 77610 | 4.9 | 191.6 | 21 | 940 |  | 38*199 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 205; K-M16 C/C min.: 940
2 x ARMERING | 20 | B500NC | P8056 | 36 | 2105 | 75780 | 5.2 | 187.3 | 21 | 1000 |  | 35*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 205; K-M16 C/C min.: 1000
3 x ARMERING | 20 | B500NC | P8056 | 4 | 2105 | 8420 | 5.2 | 20.8 | 21 | 1000 |  | 3*95 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 205; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P8056 | 15 | 2105 | 31575 | 5.2 | 78 | 21 | 1000 |  | 14*190 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 205; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P8056 | 8 | 2105 | 16840 | 5.2 | 41.6 | 21 | 1000 |  | 7*198 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 205; K-M16 C/C min.: 1000
2 x ARMERING | 20 | B500NC | P8055 | 1 | 1675 | 1675 | 4.1 | 4.1 | 00 | 1675 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8054 | 1 | 2085 | 2085 | 5.1 | 5.1 | 00 | 2085 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8053 | 1 | 2495 | 2495 | 6.2 | 6.2 | 00 | 2495 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8052 | 1 | 2905 | 2905 | 7.2 | 7.2 | 00 | 2905 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8051 | 1 | 6130 | 6130 | 15.1 | 15.1 | 00 | 6130 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8051 | 2 | 6130 | 12260 | 15.1 | 30.2 | 00 | 6130 |  | 1*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8050 | 4 | 6630 | 26520 | 16.3 | 65.4 | 00 | 6630 |  | 3*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
10 x ARMERING | 20 | B500NC | P8050 | 5 | 6625 | 33125 | 16.3 | 81.7 | 00 | 6625 |  | 4*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
4 x ARMERING | 20 | B500NC | P8001 | 1 | 7125 | 7125 | 17.6 | 17.6 | 00 | 7125 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8001 | 2 | 7125 | 14250 | 17.6 | 35.2 | 00 | 7125 |  | 1*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8049 | 2 | 7125 | 14250 | 17.6 | 35.2 | 00 | 7125 |  | 1*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8049 | 2 | 7130 | 14260 | 17.6 | 35.2 | 00 | 7130 |  | 1*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8048 | 1 | 6770 | 6770 | 16.7 | 16.7 | 00 | 6770 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8047 | 1 | 6215 | 6215 | 15.3 | 15.3 | 00 | 6215 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8046 | 1 | 5665 | 5665 | 14 | 14 | 00 | 5665 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8045 | 1 | 5110 | 5110 | 12.6 | 12.6 | 00 | 5110 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8044 | 1 | 4560 | 4560 | 11.2 | 11.2 | 00 | 4560 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8043 | 1 | 4005 | 4005 | 9.9 | 9.9 | 00 | 4005 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8042 | 1 | 3455 | 3455 | 8.5 | 8.5 | 00 | 3455 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8041 | 1 | 2900 | 2900 | 7.2 | 7.2 | 00 | 2900 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8040 | 1 | 2350 | 2350 | 5.8 | 5.8 | 00 | 2350 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8039 | 1 | 1795 | 1795 | 4.4 | 4.4 | 00 | 1795 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8038 | 1 | 1245 | 1245 | 3.1 | 3.1 | 00 | 1245 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8037 | 1 | 690 | 690 | 1.7 | 1.7 | 00 | 690 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8036 | 1 | 140 | 140 | 0.3 | 0.3 | 00 | 140 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8035 | 1 | 3785 | 3785 | 9.3 | 9.3 | 00 | 3785 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8034 | 1 | 3710 | 3710 | 9.1 | 9.1 | 00 | 3710 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8033 | 1 | 10840 | 10840 | 26.7 | 26.7 | 00 | 10840 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8032 | 1 | 10765 | 10765 | 26.5 | 26.5 | 00 | 10765 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8031 | 1 | 10695 | 10695 | 26.4 | 26.4 | 00 | 10695 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8030 | 1 | 10620 | 10620 | 26.2 | 26.2 | 00 | 10620 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8029 | 1 | 10550 | 10550 | 26 | 26 | 00 | 10550 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8028 | 1 | 10480 | 10480 | 25.8 | 25.8 | 00 | 10480 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8027 | 1 | 10405 | 10405 | 25.7 | 25.7 | 00 | 10405 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8026 | 1 | 10335 | 10335 | 25.5 | 25.5 | 00 | 10335 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8025 | 1 | 10210 | 10210 | 25.2 | 25.2 | 00 | 10210 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8024 | 1 | 10040 | 10040 | 24.8 | 24.8 | 00 | 10040 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8023 | 1 | 9875 | 9875 | 24.4 | 24.4 | 00 | 9875 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8022 | 1 | 9705 | 9705 | 23.9 | 23.9 | 00 | 9705 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8021 | 1 | 9535 | 9535 | 23.5 | 23.5 | 00 | 9535 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8020 | 1 | 9365 | 9365 | 23.1 | 23.1 | 00 | 9365 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8019 | 1 | 9195 | 9195 | 22.7 | 22.7 | 00 | 9195 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8018 | 1 | 9025 | 9025 | 22.3 | 22.3 | 00 | 9025 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8017 | 1 | 8855 | 8855 | 21.8 | 21.8 | 00 | 8855 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8016 | 1 | 8710 | 8710 | 21.5 | 21.5 | 00 | 8710 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8015 | 1 | 8635 | 8635 | 21.3 | 21.3 | 00 | 8635 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8014 | 1 | 8565 | 8565 | 21.1 | 21.1 | 00 | 8565 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8013 | 1 | 8490 | 8490 | 20.9 | 20.9 | 00 | 8490 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8012 | 1 | 8420 | 8420 | 20.8 | 20.8 | 00 | 8420 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8011 | 1 | 8345 | 8345 | 20.6 | 20.6 | 00 | 8345 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8010 | 1 | 8275 | 8275 | 20.4 | 20.4 | 00 | 8275 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8009 | 1 | 8200 | 8200 | 20.2 | 20.2 | 00 | 8200 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8008 | 1 | 8130 | 8130 | 20 | 20 | 00 | 8130 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8007 | 1 | 8055 | 8055 | 19.9 | 19.9 | 00 | 8055 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8006 | 1 | 7985 | 7985 | 19.7 | 19.7 | 00 | 7985 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8005 | 1 | 7915 | 7915 | 19.5 | 19.5 | 00 | 7915 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8004 | 1 | 7840 | 7840 | 19.3 | 19.3 | 00 | 7840 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8003 | 1 | 7770 | 7770 | 19.2 | 19.2 | 00 | 7770 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8002 | 1 | 7695 | 7695 | 19 | 19 | 00 | 7695 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 20 | B500NC | P8000 | 1 | 7050 | 7050 | 17.4 | 17.4 | 00 | 7050 |  |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
ARMERING | 20 | B500NC | P3035 | 3 | 3455 | 10365 | 8.5 | 25.6 | 00 | 3455 | SK | 1*125 + 1*150 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 20 | B500NC | P3034 | 3 | 2145 | 6435 | 5.3 | 15.9 | 00 | 2145 | SK | 1*125 + 1*150 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 20 | B500NC | P3032 | 3 | 2295 | 6885 | 5.7 | 17 | 00 | 2295 | SK | 1*125 + 1*150 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
4 x ARMERING | 25 | B500NC | P5074 | 4 | 2495 | 9980 | 9.6 | 38.5 | 99-100 | 1250 | SK | 3*100 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Brattvåg-Dryna armering - K-M14 B/B min.: 1250
2 x ARMERING | 16 | B500NC | P5073 | 3 | 2480 | 7440 | 3.9 | 11.7 | 00 | 2480 | SK | 1*150 + 1*120 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
2 x ARMERING | 16 | B500NC | P5072 | 1 | 2455 | 2455 | 3.9 | 3.9 | 00 | 2455 | SK |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
4 x ARMERING | 16 | B500NC | P7003 | 2 | 4260 | 8520 | 6.7 | 13.4 | 00 | 4260 | SK | 1*161 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 16 | B500NC | P5071 | 2 | 2280 | 4560 | 3.6 | 7.2 | 00 | 2280 | SK | 1*100 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 16 | B500NC | P5070 | 2 | 9730 | 19460 | 15.4 | 30.7 | 00 | 9730 | SK | 1*120 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 16 | B500NC | P5069 | 2 | 3510 | 7020 | 5.5 | 11.1 | 00 | 3510 | SK | 1*120 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 16 | B500NC | P5068 | 2 | 8210 | 16420 | 13 | 25.9 | 00 | 8210 | SK | 1*140 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 16 | B500NC | P5006 | 2 | 12000 | 24000 | 18.9 | 37.9 | 00 | 12000 | SK | 1*100 | BF2D@Hj10259741-01@rMC@i01@pP5006@l12000@n1@e18.94@d16@gB500NC@s0@a0@t0@Gl12000@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 16 | B500NC | P5067 | 2 | 8250 | 16500 | 13 | 26 | 00 | 8250 | SK | 1*100 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 16 | B500NC | P5066 | 2 | 4760 | 9520 | 7.5 | 15 | 00 | 4760 | SK | 1*100 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 16 | B500NC | P5065 | 2 | 5135 | 10270 | 8.1 | 16.2 | 00 | 5135 | SK | 1*80 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 16 | B500NC | P5064 | 2 | 5260 | 10520 | 8.3 | 16.6 | 00 | 5260 | SK | 1*100 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 20 | B500NC | P3031 | 3 | 1500 | 4500 | 3.7 | 11.1 | 00 | 1500 | SK | 1*25 + 1*150 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 20 | B500NC | P3027 | 2 | 1150 | 2300 | 2.8 | 5.7 | 00 | 1150 | SK | 1*175 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
2 x ARMERING | 20 | B500NC | P3027 | 3 | 1150 | 3450 | 2.8 | 8.5 | 00 | 1150 | SK | 1*125 + 1*150 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 20 | B500NC | P3030 | 3 | 5650 | 16950 | 13.9 | 41.8 | 00 | 5650 | SK | 1*125 + 1*150 | BF2D@Hj10259741-01@rMC@i01@pP3030@l2000@n1@e4.93@d20@gB500NC@s0@a0@t0@Gl2000@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
2 x ARMERING | 20 | B500NC | P3020 | 4 | 15860 | 63440 | 39.1 | 156.5 | 00 | 15860 | OK | 3*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 25 | B500NC | P5063 | 4 | 3000 | 12000 | 11.6 | 46.2 | 00 | 3000 | OK | 1*100 + 1*90 + 1*100 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 25 | B500NC | P5062 | 4 | 11200 | 44800 | 43.2 | 172.6 | 00 | 11200 | UK | 1*100 + 1*90 + 1*100 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 25 | B500NC | P5062 | 4 | 11200 | 44800 | 43.2 | 172.6 | 00 | 11200 | OK | 1*100 + 1*90 + 1*100 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 20 | B500NC | P5045 | 6 | 4405 | 26430 | 10.9 | 65.2 | 00 | 4405 | OK | 2*400 + 1*285 + 2*400 | BF2D@Hj10259741-01@rMC@i01@pP5045@l3905@n1@e9.63@d20@gB500NC@s0@a0@t0@Gl3905@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
ARMERING | 20 | B500NC | P5045 | 6 | 4405 | 26430 | 10.9 | 65.2 | 00 | 4405 | UK | 2*400 + 1*285 + 2*400 | BF2D@Hj10259741-01@rMC@i01@pP5045@l3905@n1@e9.63@d20@gB500NC@s0@a0@t0@Gl3905@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0
2 x ARMERING | 20 | B500NC | P5061 | 7 | 6030 | 42210 | 14.9 | 104.2 | 21 | 2900 | SK | 3*400 + 1*285 + 2*400 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 2900
2 x ARMERING | 20 | B500NC | P5016 | 6 | 2230 | 13380 | 5.5 | 33.1 | 21 | 1000 | SK | 2*400 + 1*345 + 2*400 | BF2D@Hj10259741-01@rMC@i01@pP5016@l2235@n1@e5.5@d20@gB500NC@s80@a0@t0@Gl1000@w90@l330@w90@l1000@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P5016 | 19 | 2230 | 42370 | 5.5 | 104.7 | 21 | 1000 | SK | 9*200 + 1*135 + 8*200 | BF2D@Hj10259741-01@rMC@i01@pP5016@l2235@n1@e5.5@d20@gB500NC@s80@a0@t0@Gl1000@w90@l330@w90@l1000@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 1000
ARMERING | 16 | B500NC | P5060 | 13 | 10000 | 130000 | 15.8 | 205.1 | 00 | 10000 | UK | 6*400 + 1*350 + 5*400 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
ARMERING | 16 | B500NC | P5060 | 13 | 10000 | 130000 | 15.8 | 205.1 | 00 | 10000 | OK | 6*400 + 1*350 + 5*400 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
ARMERING | 16 | B500NC | P5005 | 16 | 10700 | 171200 | 16.9 | 270.2 | 00 | 10700 | UK | 7*400 + 1*132 + 7*400 | BF2D@Hj10259741-01@rMC@i01@pP5005@l10360@n1@e16.35@d16@gB500NC@s0@a0@t0@Gl10360@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
ARMERING | 16 | B500NC | P5005 | 16 | 10700 | 171200 | 16.9 | 270.2 | 00 | 10700 | OK | 7*400 + 1*132 + 7*400 | BF2D@Hj10259741-01@rMC@i01@pP5005@l10360@n1@e16.35@d16@gB500NC@s0@a0@t0@Gl10360@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
ARMERING | 20 | B500NC | P5004 | 14 | 12000 | 168000 | 29.6 | 414.3 | 00 | 12000 | UK | 6*400 + 1*409 + 6*400 | BF2D@Hj10259741-01@rMC@i01@pP5004@l9995@n1@e24.65@d20@gB500NC@s0@a0@t0@Gl9995@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
ARMERING | 20 | B500NC | P5004 | 14 | 12000 | 168000 | 29.6 | 414.3 | 00 | 12000 | OK | 6*400 + 1*409 + 6*400 | BF2D@Hj10259741-01@rMC@i01@pP5004@l9995@n1@e24.65@d20@gB500NC@s0@a0@t0@Gl9995@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Omfaringslengde 50*Ø
Løpemeter | 20 | B500NC | Lm3095 | 1 | 3580 | 3580 | 8.8 | 8.8 | 00 | 3580 |  |  | BF2D@Hj10259741-01@rMC@i01@pLm3095@l865@n1@e2.13@d20@gB500NC@s0@a0@t0@Gl865@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
Løpemeter | 20 | B500NC | Lm3094 | 1 | 3605 | 3605 | 8.9 | 8.9 | 00 | 3605 |  |  | BF2D@Hj10259741-01@rMC@i01@pLm3094@l845@n1@e2.08@d20@gB500NC@s0@a0@t0@Gl845@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
Løpemeter | 20 | B500NC | Lm3082 | 3 | 3125 | 9375 | 7.7 | 23.1 | 00 | 3125 |  | 2*200 | BF2D@Hj10259741-01@rMC@i01@pLm3082@l3125@n1@e7.71@d20@gB500NC@s0@a0@t0@Gl3125@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
Løpemeter | 20 | B500NC | Lm3082 | 1 | 3125 | 3125 | 7.7 | 7.7 | 00 | 3125 |  |  | BF2D@Hj10259741-01@rMC@i01@pLm3082@l3125@n1@e7.71@d20@gB500NC@s0@a0@t0@Gl3125@w0@C73@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
Løpemeter | 20 | B500NC | Lm3143 | 1 | 3120 | 3120 | 7.7 | 7.7 | 00 | 3120 |  |  | BF2D@Hj10259741-01@rMC@i01@pLm3143@l3115@n1@e7.68@d20@gB500NC@s0@a0@t0@Gl3115@w0@C71@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
Løpemeter | 20 | B500NC | Lm3145 | 1 | 3115 | 3115 | 7.7 | 7.7 | 00 | 3115 |  |  | BF2D@Hj10259741-01@rMC@i01@pLm3145@l3115@n1@e7.67@d20@gB500NC@s0@a0@t0@Gl3115@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
Løpemeter | 20 | B500NC | Lm3079 | 1 | 3105 | 3105 | 7.7 | 7.7 | 00 | 3105 |  |  | BF2D@Hj10259741-01@rMC@i01@pLm3079@l3105@n1@e7.66@d20@gB500NC@s0@a0@t0@Gl3105@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
Løpemeter | 20 | B500NC | Lm3078 | 1 | 3100 | 3100 | 7.6 | 7.6 | 00 | 3100 |  |  | BF2D@Hj10259741-01@rMC@i01@pLm3078@l3100@n1@e7.65@d20@gB500NC@s0@a0@t0@Gl3100@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 12 | B500NC | P1006 | 1 | 6505 | 6505 | 5.8 | 5.8 | 00 | 6505 | SK |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
2 x ARMERING | 12 | B500NC | P1004 | 20 | 1655 | 33100 | 1.5 | 29.5 | 21 | 800 | UK | 18*150 + 1*50 | BF2D@Hj10259741-01@rMC@i01@pP1004@l1660@n1@e1.47@d12@gB500NC@s32@a0@t0@Gl800@w90@l110@w90@l800@w0@C86@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 110; K-M16 C/C min.: 800
2 x ARMERING | 16 | B500NC | P1007 | 1 | 6505 | 6505 | 10.3 | 10.3 | 00 | 6505 | SK |  | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
ARMERING | 12 | B500NC | P1005 | 2 | 2845 | 5690 | 2.5 | 5 | 00 | 2845 | OK | 1*100 | BF2D@Hj10259741-01@rMC@i01@pP1005@l2845@n1@e2.53@d12@gB500NC@s0@a0@t0@Gl2845@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
ARMERING | 12 | B500NC | P1005 | 2 | 2845 | 5690 | 2.5 | 5 | 00 | 2845 | UK | 1*100 | BF2D@Hj10259741-01@rMC@i01@pP1005@l2845@n1@e2.53@d12@gB500NC@s0@a0@t0@Gl2845@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
ARMERING | 12 | B500NC | P1005 | 2 | 2845 | 5690 | 2.5 | 5 | 00 | 2845 | OK | 1*150 | BF2D@Hj10259741-01@rMC@i01@pP1005@l2845@n1@e2.53@d12@gB500NC@s0@a0@t0@Gl2845@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
ARMERING | 12 | B500NC | P1005 | 2 | 2845 | 5690 | 2.5 | 5 | 00 | 2845 | UK | 1*150 | BF2D@Hj10259741-01@rMC@i01@pP1005@l2845@n1@e2.53@d12@gB500NC@s0@a0@t0@Gl2845@w0@C77@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
ARMERING | 16 | B500NC | P1003 | 47 | 1680 | 78960 | 2.7 | 124.8 | NB99-01 | 800 | UK | 23*150 + 1*30 + 22*150 | BF2D@Hj10259741-01@rMC@i01@pP1003@l1680@n1@e2.65@d16@gB500NC@s50@a0@t0@Gl800@w95.5@l140@w84.5@l800@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 140; K-M16 C/C min.: 800
ARMERING | 12 | B500NC | P1006 | 20 | 6505 | 130100 | 5.8 | 115.6 | 00 | 6505 | UK | 18*150 + 1*50 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag
ARMERING | 16 | B500NC | P1000 | 46 | 3135 | 144210 | 4.9 | 227.6 | NB99-01 | 200 | UK | 22*150 + 1*140 + 22*150 | BF2D@Hj10259741-01@rMC@i01@pP1000@l3135@n1@e4.95@d16@gB500NC@s50@a0@t0@Gl2850@w84.5@l140@w95.5@l200@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | Brattvåg-Dryna armering - K-M14 B/B min.: 140; K-M16 C/C min.: 2850
ARMERING | 20 | B500NC | P3033 | 5 | 3730 | 18650 | 9.2 | 46 | 31 | 1360 | Lag 2 | 1*75 + 3*200 | BF2D@Hj10259741-01@rMC@i01@pP3033@l3730@n1@e9.2@d20@gB500NC@s80@a0@t0@Gl265@w90@l360@w90@l1360@w90@l360@w90@l1360@w90@l265@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 360; K-M10 Krok Start: 1; K-M16 C/C min.: 1360; K-M18 D/D min.: 360
ARMERING | 20 | B500NC | P5055 | 11 | 5310 | 58410 | 13.1 | 144.2 | 21 | 2500 | YK | 9*200 + 1*110 | BF2D@Hj10259741-01@rMC@i01@pP5055@l5315@n1@e13.09@d20@gB500NC@s80@a0@t0@Gl2500@w90@l410@w90@l2500@w0@C87@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 2500
ARMERING | 20 | B500NC | P5007 | 62 | 6580 | 407960 | 16.2 | 1006.4 | 21 | 2480 | UK | 30*200 + 1*35 + 30*200 | BF2D@Hj10259741-01@rMC@i01@pP5007@l6580@n1@e16.23@d20@gB500NC@s80@a0@t0@Gl165@w180@l2480@w90@l1315@w90@l2480@w180@l165@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 1315; K-M10 Krok Start: 3; K-M16 C/C min.: 2480
ARMERING | 16 | B500NC | P5006 | 2 | 12000 | 24000 | 18.9 | 37.9 | 00 | 12000 | OK/UK | 1*255 | BF2D@Hj10259741-01@rMC@i01@pP5006@l12000@n1@e18.94@d16@gB500NC@s0@a0@t0@Gl12000@w0@C72@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 20 | B500NC | P5054 | 61 | 4430 | 270230 | 10.9 | 667.1 | 21 | 1900 | SK | 30*200 + 1*175 + 29*200 | BF2D@Hj10259741-01@rMC@i01@pP5054@l4435@n1@e10.92@d20@gB500NC@s80@a0@t0@Gl165@w180@l1900@w90@l330@w90@l1900@w180@l165@w0@C96@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 1 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 330; K-M10 Krok Start: 3; K-M16 C/C min.: 1900
ARMERING | 16 | B500NC | P5015 | 72 | 1860 | 133920 | 2.9 | 211.3 | 21 | 800 | SK | 35*200 + 1*180 + 35*200 | BF2D@Hj10259741-01@rMC@i01@pP5015@l1860@n1@e2.94@d16@gB500NC@s50@a0@t0@Gl800@w90@l330@w90@l800@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 330; K-M16 C/C min.: 800
ARMERING | 20 | B500NC | P3029 | 2 | 2500 | 5000 | 6.2 | 12.3 | 00 | 2500 | - | 1*50 | BF2D@Hj10259741-01@rMC@i01@pP3029@l2500@n1@e6.17@d20@gB500NC@s0@a0@t0@Gl2500@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Vegg
ARMERING | 20 | B500NC | P3028 | 10 | 4310 | 43100 | 10.6 | 106.4 | 21 | 2400 | Lag 1 | 1*65 + 8*200 | BF2D@Hj10259741-01@rMC@i01@pP3028@l4315@n1@e10.63@d20@gB500NC@s80@a0@t0@Gl1300@w90@l710@w90@l2400@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 710; K-M16 C/C min.: 1300; K-M33 Merknader til utførelse 1: Tilpasses mot berg
2 x ARMERING | 20 | B500NC | P5052 | 2 | 4125 | 8250 | 10.2 | 20.4 | 21 | 2000 | OK | 1*120 | BF2D@Hj10259741-01@rMC@i01@pP5052@l4130@n1@e10.17@d20@gB500NC@s80@a0@t0@Gl2000@w90@l225@w90@l2000@w0@C74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 225; K-M16 C/C min.: 2000
3 x ARMERING | 20 | B500NC | P5053 | 2 | 4175 | 8350 | 10.3 | 20.6 | 21 | 2000 | OK | 1*150 | BF2D@Hj10259741-01@rMC@i01@pP5053@l4180@n1@e10.3@d20@gB500NC@s80@a0@t0@Gl2000@w90@l275@w90@l2000@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 275; K-M16 C/C min.: 2000
ARMERING | 20 | B500NC | P5053 | 2 | 4175 | 8350 | 10.3 | 20.6 | 21 | 2000 | OK | 1*115 | BF2D@Hj10259741-01@rMC@i01@pP5053@l4180@n1@e10.3@d20@gB500NC@s80@a0@t0@Gl2000@w90@l275@w90@l2000@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 275; K-M16 C/C min.: 2000
ARMERING | 20 | B500NC | P5053 | 2 | 4175 | 8350 | 10.3 | 20.6 | 21 | 2000 | OK | 1*160 | BF2D@Hj10259741-01@rMC@i01@pP5053@l4180@n1@e10.3@d20@gB500NC@s80@a0@t0@Gl2000@w90@l275@w90@l2000@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 275; K-M16 C/C min.: 2000
ARMERING | 20 | B500NC | P5053 | 2 | 4175 | 8350 | 10.3 | 20.6 | 21 | 2000 | OK | 1*125 | BF2D@Hj10259741-01@rMC@i01@pP5053@l4180@n1@e10.3@d20@gB500NC@s80@a0@t0@Gl2000@w90@l275@w90@l2000@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 275; K-M16 C/C min.: 2000
2 x ARMERING | 20 | B500NC | P5059 | 1 | 5940 | 5940 | 14.6 | 14.6 | 21 | 2500 | Tilpasses bolter |  | BF2D@Hj10259741-01@rMC@i01@pP5059@l5940@n1@e14.65@d20@gB500NC@s80@a0@t0@Gl2500@w90@l1035@w90@l2500@w0@C88@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Bjelke | Brattvåg-Dryna armering - K-M14 B/B min.: 1035; K-M16 C/C min.: 2500
ARMERING | 25 | B500NC | P5011 | 2 | 12000 | 24000 | 46.2 | 92.5 | 00 | 12000 | OK | 1*1238 | BF2D@Hj10259741-01@rMC@i01@pP5011@l12000@n1@e46.24@d25@gB500NC@s0@a0@t0@Gl12000@w0@C82@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Bjelke
ARMERING | 20 | B500NC | P3026 | 7 | 3160 | 22120 | 7.8 | 54.6 | 21 | 1500 | SK | 1*137 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP3026@l3165@n1@e7.79@d20@gB500NC@s80@a0@t0@Gl1500@w90@l260@w90@l1500@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 260; K-M16 C/C min.: 1500
ARMERING | 20 | B500NC | P3004 | 10 | 1210 | 12100 | 3 | 29.8 | 00 | 1210 | SK | 8*200 + 1*115 | BF2D@Hj10259741-01@rMC@i01@pP3004@l1210@n1@e2.98@d20@gB500NC@s0@a0@t0@Gl1210@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg
ARMERING | 20 | B500NC | P3024 | 7 | 1660 | 11620 | 4.1 | 28.7 | 00 | 1660 | SK | 5*200 + 1*73 | BF2D@Hj10259741-01@rMC@i01@pP3024@l1660@n1@e4.09@d20@gB500NC@s0@a0@t0@Gl1660@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg
ARMERING | 20 | B500NC | P3004 | 10 | 1210 | 12100 | 3 | 29.8 | 00 | 1210 | SK | 1*110 + 8*200 | BF2D@Hj10259741-01@rMC@i01@pP3004@l1210@n1@e2.98@d20@gB500NC@s0@a0@t0@Gl1210@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Vegg
ARMERING | 20 | B500NC | P3025 | 7 | 2160 | 15120 | 5.3 | 37.4 | 21 | 1000 | SK | 1*137 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP3025@l2165@n1@e5.33@d20@gB500NC@s80@a0@t0@Gl1000@w90@l260@w90@l1000@w0@C87@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 260; K-M16 C/C min.: 1000
ARMERING | 20 | B500NC | P3024 | 7 | 1660 | 11620 | 4.1 | 28.7 | 00 | 1660 | SK | 1*73 + 5*200 | BF2D@Hj10259741-01@rMC@i01@pP3024@l1660@n1@e4.09@d20@gB500NC@s0@a0@t0@Gl1660@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Lengdearmering | Vegg
ARMERING | 20 | B500NC | P3023 | 10 | 3210 | 32100 | 7.9 | 79.3 | 21 | 1500 | OK | 1*55 + 8*200 | BF2D@Hj10259741-01@rMC@i01@pP3023@l3215@n1@e7.92@d20@gB500NC@s80@a0@t0@Gl1500@w90@l310@w90@l1500@w0@C79@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 310; K-M16 C/C min.: 1500
ARMERING | 20 | B500NC | P3022 | 10 | 1825 | 18250 | 4.5 | 45.1 | 99 |  | UK | 1*85 + 8*200 | BF2D@Hj10259741-01@rMC@i01@pP3022@l1825@n1@e4.5@d20@gB500NC@s50@a0@t0@Gl800@w90@l310@w90@l800@w0@C67@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg
ARMERING | 20 | B500NC | P3018 | 2 | 3910 | 7820 | 9.6 | 19.3 | 00 | 3910 | - | 1*103 | BF2D@Hj10259741-01@rMC@i01@pP3018@l3910@n1@e9.64@d20@gB500NC@s0@a0@t0@Gl3910@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Vegg
2 x ARMERING | 20 | B500NC | P3015 | 3 | 4355 | 13065 | 10.7 | 32.2 | 00 | 4355 | SK | 1*185 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP3015@l4355@n1@e10.74@d20@gB500NC@s0@a0@t0@Gl4355@w0@C93@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Vegg
ARMERING | 20 | B500NC | P3019 | 6 | 3355 | 20130 | 8.3 | 49.7 | NB99-12 | 945 | Tilpasses innstøpningsgods | 1*75 + 1*100 + 1*75 + 1*100 + 1*75 | BF2D@Hj10259741-01@rMC@i01@pP3019@l3355@n1@e8.27@d20@gB500NC@s80@a0@t0@Gl165@w180@l945@w90@l270@w90@l1065@w41.5@l780@w180@l165@w0@C69@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Vegg | Brattvåg-Dryna armering - K-M11 Krok slutt: 3; K-M14 B/B min.: 270; K-M10 Krok Start: 3; K-M16 C/C min.: 1065; K-M18 D/D min.: 780
ARMERING | 20 | B500NC | P3007 | 21 | 4350 | 91350 | 10.7 | 225.3 | 99 |  | Lag 1 | 1*75 + 19*200 | BVBS does not existC74@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M10 Krok Start: 1
ARMERING | 20 | B500NC | P3006 | 3 | 800 | 2400 | 2 | 5.9 | 00 | 800 | Ift. innstøpningsgods | 2*225 | BF2D@Hj10259741-01@rMC@i01@pP3006@l800@n1@e1.97@d20@gB500NC@s0@a0@t0@Gl800@w0@C90@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Vegg | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Armeringsjern trees gjennom innstøpningsgods
ARMERING | 16 | B500NC | P5043 | 14 | 3000 | 42000 | 4.7 | 66.3 | 00 | 3000 | OK | 13*200 | BF2D@Hj10259741-01@rMC@i01@pP5043@l3000@n1@e4.73@d16@gB500NC@s0@a0@t0@Gl3000@w0@C95@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
20 x ARMERING | 20 | B500NC | P4019 | 1 | 2350 | 2350 | 5.8 | 5.8 | 21 | 1000 | OK |  | BF2D@Hj10259741-01@rMC@i01@pP4019@l2350@n1@e5.8@d20@gB500NC@s80@a0@t0@Gl1000@w90@l445@w90@l1000@w0@C96@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Utstøpt stålrør | Brattvåg-Dryna armering - K-M14 B/B min.: 445; K-M16 C/C min.: 1000
20 x ARMERING | 20 | B500NC | P4020 | 1 | 2445 | 2445 | 6 | 6 | 21 | 1000 | OK |  | BF2D@Hj10259741-01@rMC@i01@pP4020@l2445@n1@e6.03@d20@gB500NC@s80@a0@t0@Gl1000@w90@l540@w90@l1000@w0@C91@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Utstøpt stålrør | Brattvåg-Dryna armering - K-M14 B/B min.: 540; K-M16 C/C min.: 1000
10 x ARMERING | 16 | B500NC | P4009 | 5 | 2485 | 12425 | 3.9 | 19.6 | 67 | 2490 | Lag 1 | 4*150 |  | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Utstøpt stålrør
2 x ARMERING | 16 | B500NC | P4009 | 51 | 2485 | 126735 | 3.9 | 200.1 | 67 | 2490 | Lag 1 | 50*198 |  | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tverrarmering | Utstøpt stålrør
2 x ARMERING | 32 | B500NC | P4008 | 12 | 12705 | 152460 | 80.2 | 962.5 | 00 | 12705 | Lag 2 | 11*150 | BF2D@Hj10259741-01@rMC@i01@pP4008@l12705@n1@e80.21@d32@gB500NC@s0@a0@t0@Gl12705@w0@C92@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Hovedarmering | Utstøpt stålrør | Brattvåg-Dryna armering - K-M33 Merknader til utførelse 1: Utføres med T-hoder HRC110 eller tilsvarende
5 x ARMERING | 32 | B500NC | P4005 | 6 | 5000 | 30000 | 31.6 | 189.4 | 00 | 5000 | Lag 2 | 5*306 | BF2D@Hj10259741-01@rMC@i01@pP4005@l5000@n1@e31.57@d32@gB500NC@s0@a0@t0@Gl5000@w0@C78@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Utstøpt stålrør
ARMERING | 20 | B500NC | P3010 | 5 | 2260 | 11300 | 5.6 | 27.9 | 21 | 1000 | UK | 1*184 + 3*200 | BF2D@Hj10259741-01@rMC@i01@pP3010@l2265@n1@e5.57@d20@gB500NC@s80@a0@t0@Gl1000@w90@l360@w90@l1000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3010 | 1 | 2260 | 2260 | 5.6 | 5.6 | 21 | 1000 | SK |  | BF2D@Hj10259741-01@rMC@i01@pP3010@l2265@n1@e5.57@d20@gB500NC@s80@a0@t0@Gl1000@w90@l360@w90@l1000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3010 | 6 | 2260 | 13560 | 5.6 | 33.5 | 21 | 1000 | UK | 1*94 + 4*200 | BF2D@Hj10259741-01@rMC@i01@pP3010@l2265@n1@e5.57@d20@gB500NC@s80@a0@t0@Gl1000@w90@l360@w90@l1000@w0@C85@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 6 | 2310 | 13860 | 5.7 | 34.2 | 21 | 1000 | UK | 1*44 + 4*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 4 | 2310 | 9240 | 5.7 | 22.8 | 21 | 1000 | UK | 1*74 + 2*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 5 | 2310 | 11550 | 5.7 | 28.5 | 21 | 1000 | UK | 1*116 + 3*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 25 | 2310 | 57750 | 5.7 | 142.7 | 21 | 1000 | UK | 1*45 + 23*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 6 | 2310 | 13860 | 5.7 | 34.2 | 21 | 1000 | UK | 1*59 + 4*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 15 | 2310 | 34650 | 5.7 | 85.6 | 21 | 1000 | UK | 1*113 + 13*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3013 | 16 | 3260 | 52160 | 8 | 128.8 | 21 | 1500 | SK | 1*189 + 14*200 | BF2D@Hj10259741-01@rMC@i01@pP3013@l3265@n1@e8.04@d20@gB500NC@s80@a0@t0@Gl1500@w90@l360@w90@l1500@w0@C76@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1500; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3013 | 3 | 3260 | 9780 | 8 | 24.1 | 21 | 1500 | SK | 1*181 + 1*200 | BF2D@Hj10259741-01@rMC@i01@pP3013@l3265@n1@e8.04@d20@gB500NC@s80@a0@t0@Gl1500@w90@l360@w90@l1500@w0@C76@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 360; K-M16 C/C min.: 1500; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 20 | B500NC | P3011 | 22 | 2310 | 50820 | 5.7 | 125.6 | 21 | 1000 | UK | 1*184 + 20*200 | BF2D@Hj10259741-01@rMC@i01@pP3011@l2315@n1@e5.7@d20@gB500NC@s80@a0@t0@Gl1000@w90@l410@w90@l1000@w0@C81@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Vegg | Brattvåg-Dryna armering - K-M14 B/B min.: 410; K-M16 C/C min.: 1000; K-M33 Merknader til utførelse 1: Tilpasses bergoverflate
ARMERING | 16 | B500NC | P5044 | 4 | 2000 | 8000 | 3.2 | 12.6 | 00 | 2000 | OK | 1*60 + 1*110 + 1*80 | BF2D@Hj10259741-01@rMC@i01@pP5044@l2000@n1@e3.16@d16@gB500NC@s0@a0@t0@Gl2000@w0@C68@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
2 x ARMERING | 16 | B500NC | P5051 | 3 | 1550 | 4650 | 2.4 | 7.4 | 31 | 330 | v/bolter | 1*150 + 1*130 | BF2D@Hj10259741-01@rMC@i01@pP5051@l1555@n1@e2.45@d16@gB500NC@s50@a0@t0@Gl205@w90@l330@w90@l330@w90@l330@w90@l330@w90@l205@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 330; K-M10 Krok Start: 1; K-M16 C/C min.: 330; K-M18 D/D min.: 330; K-M33 Merknader til utførelse 1: Tilpasses bolter
4 x ARMERING | 20 | B500NC | P7004 | 7 | 2150 | 15050 | 5.3 | 37.2 | 21 | 1000 | SK | 6*200 | BF2D@Hj10259741-01@rMC@i01@pP7004@l2155@n1@e5.3@d20@gB500NC@s80@a0@t0@Gl1000@w90@l250@w90@l1000@w0@C75@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Brystningselement | Brattvåg-Dryna armering - K-M14 B/B min.: 250; K-M16 C/C min.: 1000
ARMERING | 16 | B500NC | P7011 | 3 | 1470 | 4410 | 2.3 | 7 | 31 | 310 | OK | 1*150 + 1*160 | BF2D@Hj10259741-01@rMC@i01@pP7011@l1470@n1@e2.32@d16@gB500NC@s50@a0@t0@Gl205@w90@l310@w90@l310@w90@l310@w90@l310@w90@l205@w0@C84@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 1 | Tilleggsarmering | Brystningselement | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 305; K-M10 Krok Start: 1; K-M16 C/C min.: 310; K-M18 D/D min.: 305; K-M33 Merknader til utførelse 1: Tilpasses bolter
ARMERING | 16 | B500NC | P5042 | 4 | 4000 | 16000 | 6.3 | 25.2 | 00 | 4000 | OK | 1*60 + 1*110 + 1*80 | BF2D@Hj10259741-01@rMC@i01@pP5042@l4000@n1@e6.31@d16@gB500NC@s0@a0@t0@Gl4000@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke
ARMERING | 16 | B500NC | P5017 | 4 | 1820 | 7280 | 2.9 | 11.5 | 21 | 800 | SK | 1*60 + 1*110 + 1*60 | BF2D@Hj10259741-01@rMC@i01@pP5017@l1820@n1@e2.87@d16@gB500NC@s50@a0@t0@Gl800@w90@l290@w90@l800@w0@C94@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyler | Kaidekke | Brattvåg-Dryna armering - K-M14 B/B min.: 290; K-M16 C/C min.: 800
ARMERING | 16 | B500NC | P5051 | 3 | 1550 | 4650 | 2.4 | 7.4 | 31 | 330 | v/bolter | 2*150 | BF2D@Hj10259741-01@rMC@i01@pP5051@l1555@n1@e2.45@d16@gB500NC@s50@a0@t0@Gl205@w90@l330@w90@l330@w90@l330@w90@l330@w90@l205@w0@C66@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Tilleggsarmering | Kaidekke | Brattvåg-Dryna armering - K-M11 Krok slutt: 1; K-M14 B/B min.: 330; K-M10 Krok Start: 1; K-M16 C/C min.: 330; K-M18 D/D min.: 330; K-M33 Merknader til utførelse 1: Tilpasses bolter
9 x ARMERING | 20 | B500NC | P4014 | 2 | 3430 | 6860 | 8.5 | 16.9 | 21 | 1300 | OK | 1*974 | BF2D@Hj10259741-01@rMC@i01@pP4014@l3435@n1@e8.46@d20@gB500NC@s80@a0@t0@Gl1300@w90@l930@w90@l1300@w0@C70@ | 350 | \Vedlegg | \Beskrivelse | \32_tegninger_pdf | 05.06.2026 | Tilbudsgrunnlag | - | 0 | Bøyle | Kumring | Brattvåg-Dryna armering - K-M14 B/B min.: 930; K-M16 C/C min.: 1300
