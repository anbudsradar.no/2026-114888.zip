Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Default Description]
File name: \\trh-nasuni-01\TRH_Prosjekt\O10259\10259741-01\03_ARBEIDSOMRAADE\11_m_fag\02_bru\Modeller\Brattvåg\Global\f_va.ifc
Time: 2026-09-11T10:16:50
Author: Tirill Sandstø
Organization: Trimble Solutions Sandvika AS
Written by: Ifc Engine <1.0.1.1374>
Made in: Trimble Inc. - Novapoint - 28.0.654.0
Authorization: Tirill Sandstø

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
Description: Description of Site; RefLatitude: 6, 26, 52; RefLongitude: 62, 36, 28; RefElevation: -2.99451 m

# IfcBuilding, Default Building
Description: Description of Building; ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingStorey
In: Default Building
Description: Land Development storey; Elevation: 0 m

# IfcDistributionFlowElement (7)
Novapoint UtilityNetwork - ManholeHasLadder: 0
Name | Name | Navn = ManholeName | ManholeMateriale | ManholeHeight | ManholeElevationAtTop | ManholeTaperDiameter | ManholeAdjustingUnitHeight | ManholeInnerBottomZ | ManholeSumpDepth | UtilityNetworkType | Bruksomraade | Diameter (DN) | Color
f-va, VK1 | f-va, VK1 | VK1 | Betong | 1.46 | 2.17 | 800 | 450 | 0.71 | 0 | WS_WaterPipeNetwork | Inspeksjonskum | 1600 | 0,0,255
f-va, S3 | f-va, S3 | S3 | Plast | 1 | 2.2 | 400 | 100 | 1.2 | 0 | WS_SewerNetwork | Inspeksjonskum | 425 | 0,255,0
f-va, S1 | f-va, S1 | S1 | Plast | 0.893166 | 2.89317 | 400 | 100 | 2 | 0 | WS_SewerNetwork | Inspeksjonskum | 425 | 0,255,0
f-va, S2 | f-va, S2 | S2 | Plast | 1.06096 | 2.9 | 400 | 100 | 1.83904 | 0 | WS_SewerNetwork | Inspeksjonskum | 425 | 0,255,0
f-va, SF | f-va, SF | SF | Betong | 2.37 | 2.67 | 650 | 0 | 0.3 | 1000 | WS_StormwaterPipeNetwork | Inntak | 1000 | 0,0,0
f-va, S | f-va, S | S | Plast | 0.660333 | 2.42033 | 0 | 0 | 1.76 | -1179 | WS_SewerNetwork | Inspeksjonskum | 400 | 0,255,0
f-va, HS | f-va, HS | HS | Plast | 0.66 | 2.42 | 0 | 0 | 1.76 | -1179 | WS_SewerNetwork | Inspeksjonskum | 400 | 0,255,0

# IfcFlowSegment (14)
Novapoint UtilityNetwork - Volume: 0 m3
Name | Color | PipeName | Navn = ManholeName | PipeClass | PipeMaterial | UtilityNetworkType | PipeType | PipeWallThickness | PipeHorizontalLength | PipeDeltaZ | PipeGradient | Bruk | Diameter (DN) | Length (m) | Volume (m3) | Height (m) | ShortestHorizontalLength (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2) | FromConnection
f-va, SP til sjo, Spillvannsledning | 0,255,0 | Spillvannsledning | Spillvannsledning | SN8 | PVC grunnavløpsrør | WS_SewerNetwork | SewerPipe | 0.1 | 1.138 | 0 | 0 | Waste Water | 1200 | 1.138 | 0.000428691 | 1.19985 | 0.0239022 | 0.0239022 | 0.000227542 | Novapoint UtilityNetwork - PipeUserDefineId: Slamavskiller_utløp; ToConnection: f-va, S
f-va, Utløp, Spillvannsledning | 0,255,0 | Spillvannsledning | Spillvannsledning | SN 8 | PVC grunnavløpsrør | WS_SewerNetwork | SewerPipe | 4.7 | 3.32423 | -0.28 | -0.08423 | Waste Water | 160 | 3.336 | 0.00764458 | 0.439415 | 0.0198425 | 1.86091 | 1.8202 | Novapoint UtilityNetwork - ToConnection: f-va, S3
f-va, Utløp, Spillvannsledning | 0,255,0 | Spillvannsledning | Spillvannsledning | SDR 11 | PE 100 | WS_SewerNetwork | SewerPipe | 14.6 | 6.72508 | -1.19287 | -0.177376 | Waste Water | 160 | 6.83005 | 0.0455197 | 1.35039 | 0.00167921 | 6.72884 | 1.07925 | f-va, S3
f-va, SP til sjo, Spillvannsledning | 0,255,0 | Spillvannsledning | Spillvannsledning | SN 8 | PVC grunnavløpsrør | WS_SewerNetwork | SewerPipe | 3.2 | 1.05691 | -0.4 | -0.378461 | Waste Water | 110 | 1.13007 | 0.00121251 | 0.502866 | 2.36113 | 2.36113 | 0.119593 | Novapoint UtilityNetwork - ToConnection: f-va, S1
f-va, SP til sjo, Spillvannsledning | 0,255,0 | Spillvannsledning | Spillvannsledning | SN 8 | PVC grunnavløpsrør | WS_SewerNetwork | SewerPipe | 3.2 | 3.73152 | -0.147441 | -0.0395123 | Waste Water | 110 | 3.73443 | 0.00400686 | 0.257341 | 0.10982 | 3.43399 | 0.410791 | f-va, S1 | Novapoint UtilityNetwork - ToConnection: f-va, S2
f-va, SP til sjo, Spillvannsledning | 0,255,0 | Spillvannsledning | Spillvannsledning | SN 8 | PVC grunnavløpsrør | WS_SewerNetwork | SewerPipe | 3.2 | 7.01879 | -0.259044 | -0.0369072 | Waste Water | 110 | 7.02372 | 0.0075361 | 0.368946 | 0.109686 | 5.32494 | 0.772318 | f-va, S2
f-va, Utløp, Spillvannsledning | 0,255,0 | Spillvannsledning | Spillvannsledning | SN 8 | PVC grunnavløpsrør | WS_SewerNetwork | SewerPipe | 4.7 | 11.5786 | -3.00156 | -0.259234 | Waste Water | 160 | 11.9613 | 0.0274098 | 3.15642 | 0.00271228 | 11.7494 | 1.85715
f-va, SP til sjo, Spillvannsledning | 0,255,0 | Spillvannsledning | Spillvannsledning | SN8 | PVC grunnavløpsrør | WS_SewerNetwork | SewerPipe | 0.1 | 2.37409 | 0 | 0 | Waste Water | 1200 | 2.37409 | 0.000894336 | 1.19985 | 1.14957 | 1.14957 | 0.000474699 | f-va, S | Novapoint UtilityNetwork - ToConnection: f-va, HS
f-va, SP til sjo, Spillvannsledning | 0,255,0 | Spillvannsledning | Spillvannsledning | SN8 | PVC grunnavløpsrør | WS_SewerNetwork | SewerPipe | 0.1 | 0.807931 | 0 | 0 | Waste Water | 1200 | 0.807931 | 0.000304353 | 1.19985 | 0.807931 | 1.1995 | 0.000161545 | f-va, HS
f-va, Trase1, Overvannsledning | 0,0,0 |  | Overvannsledning | SN8 | DV_OV | WS_StormwaterPipeNetwork | StormwaterPipe | 10 | 1.94776 | -0.156884 | -0.0805457 |  | 150 | 1.95407 | 0.00981564 | 0.326314 | 0.00133903 | 1.94863 | 0.332858 | f-va, SF | Novapoint UtilityNetwork - Name: f-va, Trase1, Overvannsledning; PipeNetworkUsage: Surface Water
f-va, Trase2, Overvannsledning | 0,0,0 |  | Overvannsledning | SN8 | DV_OV | WS_StormwaterPipeNetwork | StormwaterPipe | 10 | 1.0789 | -0.010789 | -0.00999997 |  | 150 | 1.07896 | 0.00541979 | 0.180759 | 0.169462 | 1.07907 | 0.183594 | Novapoint UtilityNetwork - Name: f-va, Trase2, Overvannsledning; PipeNetworkUsage: Surface Water
f-va, Trase2, Overvannsledning | 0,0,0 |  | Overvannsledning | SN8 | DV_OV | WS_StormwaterPipeNetwork | StormwaterPipe | 10 | 35.9529 | -0.359529 | -0.01 |  | 150 | 35.9547 | 0.180607 | 0.529499 | 0.169808 | 32.3083 | 6.11107 | f-va, VK1 | Novapoint UtilityNetwork - Name: f-va, Trase2, Overvannsledning; PipeNetworkUsage: Surface Water
f-va, Til toalettbygg, Vannledning |  |  | Vannledning | SDR 11 | PE 100 |  | CableDrawingPipe | 3 | 34.4837 | 1.6795 | 0.0487043 |  | 32 |  | 0.00944919 | 1.71147 | 0.00147635 | 29.3829 | 1.67876 | f-va, VK1
f-va, VL, Vannledning |  |  | Vannledning | SDR 11 | PE 100 |  | CableDrawingPipe | 4.6 | 41.6917 | -1.81 | -0.0434139 |  | 50 |  | 0.0283027 | 1.86 | 0.049687 | 41.5667 | 2.09633 | Novapoint UtilityNetwork - ToConnection: f-va, VK1

# IfcFlowTerminal (30)
Name | Color | ManholeName | ManholeDiameter | ManholeMaterial | ManholeHeight | ManholeMateriale | UtilityNetworkType | Novapoint UtilityNetwork, Volume (m3) = TRMB_QUADRI_Qto_BaseQuantities, Volume (m3) | Height (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2) | ManholeInnerBottomZ | ManholeSumpDepth | Bruksomraade
f-va, VK1, Kjegle | 0,0,255 | VK1 | 1600 | Betong | 1.46 | Betong | WS_WaterPipeNetwork | 0.000439956 | 0.001 | 5.58926 | 2.48679 | Novapoint UtilityNetwork - ManholeTaperHeight: 1; ManholeTaperDiameter: 800; Bruksomraade 1269: Inspeksjonskum
f-va, S3, Kjegle | 0,255,0 | S3 | 425 | Plast | 1 | Plast | WS_SewerNetwork | 0.0000366196 | 0.01 | 1.33433 | 0.141767 | Novapoint UtilityNetwork - ManholeTaperHeight: 10; ManholeTaperDiameter: 400; Bruksomraade 1269: Inspeksjonskum
f-va, S1, Kjegle | 0,255,0 | S1 | 425 | Plast | 0.893166 | Plast | WS_SewerNetwork | 0.00000366196 | 0.001 | 1.33434 | 0.141762 | Novapoint UtilityNetwork - ManholeTaperHeight: 1; ManholeTaperDiameter: 400; Bruksomraade 1269: Inspeksjonskum
f-va, S2, Kjegle | 0,255,0 | S2 | 425 | Plast | 1.06096 | Plast | WS_SewerNetwork | 0.00000366196 | 0.001 | 1.33433 | 0.141767 | Novapoint UtilityNetwork - ManholeTaperHeight: 1; ManholeTaperDiameter: 400; Bruksomraade 1269: Inspeksjonskum
f-va, SF, Kjegle | 0,0,0 | SF | 1000 | Betong | 2.37 | Betong | WS_StormwaterPipeNetwork | 0.141879 | 0.5 | 3.74234 | 1.09281 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: Inntak; TRMB_QUADRI_Qto_BaseQuantities - ShortestHorizontalLength: 0.037439 m
f-va, VK1, Bunnseksjon | 0,0,255 |  |  |  |  | Betong | WS_WaterPipeNetwork |  |  |  |  | 0.71 | 0 | Inspeksjonskum
f-va, S1, Bunnseksjon | 0,255,0 |  |  |  |  | Plast | WS_SewerNetwork |  |  |  |  | 2 | 0 | Inspeksjonskum
f-va, S3, Bunnseksjon | 0,255,0 |  |  |  |  | Plast | WS_SewerNetwork |  |  |  |  | 1.2 | 0 | Inspeksjonskum
f-va, SF, Bunnseksjon | 0,0,0 |  |  |  |  | Betong | WS_StormwaterPipeNetwork |  |  |  |  | 0.3 | 1000 | Inntak
f-va, S, Bunnseksjon | 0,255,0 |  |  |  |  | Plast | WS_SewerNetwork |  |  |  |  | 1.76 | -1179 | Inspeksjonskum
f-va, S2, Bunnseksjon | 0,255,0 |  |  |  |  | Plast | WS_SewerNetwork |  |  |  |  | 1.83904 | 0 | Inspeksjonskum
f-va, HS, Bunnseksjon | 0,255,0 |  |  |  |  | Plast | WS_SewerNetwork |  |  |  |  | 1.76 | -1179 | Inspeksjonskum
f-va, S3, Justeringsring | 0,255,0 | S3 | 425 | Plast | 1 | Plast | WS_SewerNetwork | 0.000344502 | 0.1 | 1.25584 | 0.125579 |  |  | Inspeksjonskum | Novapoint UtilityNetwork - ManholeTaperDiameter: 400; ManholeAdjustingHeight: 100; ManholeAdjustingDiameter: 400; ManholeAdjustingUnitHeight: 100
f-va, VK1, Justeringsring | 0,0,255 | VK1 | 1600 | Betong | 1.46 | Betong | WS_WaterPipeNetwork | 0.104262 | 0.45 | 3.07693 | 0.251473 |  |  | Inspeksjonskum | Novapoint UtilityNetwork - ManholeTaperDiameter: 800; ManholeAdjustingHeight: 450; ManholeAdjustingDiameter: 800; ManholeAdjustingUnitHeight: 450
f-va, S2, Justeringsring | 0,255,0 | S2 | 425 | Plast | 1.06096 | Plast | WS_SewerNetwork | 0.000344502 | 0.1 | 1.25584 | 0.125579 |  |  | Inspeksjonskum | Novapoint UtilityNetwork - ManholeTaperDiameter: 400; ManholeAdjustingHeight: 100; ManholeAdjustingDiameter: 400; ManholeAdjustingUnitHeight: 100
f-va, S1, Justeringsring | 0,255,0 | S1 | 425 | Plast | 0.893166 | Plast | WS_SewerNetwork | 0.000344502 | 0.1 | 1.25584 | 0.125579 |  |  | Inspeksjonskum | Novapoint UtilityNetwork - ManholeTaperDiameter: 400; ManholeAdjustingHeight: 100; ManholeAdjustingDiameter: 400; ManholeAdjustingUnitHeight: 100
f-va, VK1, Lokk |  | VK1 |  |  |  |  | WS_WaterPipeNetwork | 0.006945 | 0.01 | 3.07693 | 0.75379 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 800; ManholeCoverType: Flatt lokk
f-va, S3, Lokk |  | S3 |  |  |  |  | WS_SewerNetwork | 0.00150412 | 0.01 | 1.25585 | 0.125574 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: Flatt lokk
f-va, S1, Lokk |  | S1 |  |  |  |  | WS_SewerNetwork | 0.00150412 | 0.01 | 1.25585 | 0.125574 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: Flatt lokk
f-va, SF, Lokk |  | SF |  |  |  |  | WS_StormwaterPipeNetwork | 0.00498168 | 0.01 | 2.60597 | 0.540698 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: Flatt lokk
f-va, S2, Lokk |  | S2 |  |  |  |  | WS_SewerNetwork | 0.00150412 | 0.01 | 1.25585 | 0.125574 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 400; ManholeCoverType: Flatt lokk
f-va, VK1, Bunnplate | 0,0,255 | VK1 | 1600 | Betong | 1.46 | Betong | WS_WaterPipeNetwork | 0.229118 | 0.1 | 5.58928 | 2.48679 | 0.71 | 0 | Inspeksjonskum
f-va, SF, Bunnplate | 0,0,0 | SF | 1000 | Betong | 2.37 | Betong | WS_StormwaterPipeNetwork | 0.100689 | 0.1 | 3.70499 | 1.09285 | 0.3 | 1000 | Inntak
f-va, VK1, Bunnring | 0,0,255 | VK1 | 1600 | Betong | 1.46 | Betong | WS_WaterPipeNetwork | 0.443916 | 1.009 | 5.58922 | 0.477516 | 0.71 | 0 | Inspeksjonskum
f-va, S1, Bunnring | 0,255,0 | S1 | 425 | Plast | 0.893166 | Plast | WS_SewerNetwork | 0.00290088 | 0.792166 | 1.33434 | 0.141762 | 2 | 0 | Inspeksjonskum
f-va, S3, Bunnring | 0,255,0 | S3 | 425 | Plast | 1 | Plast | WS_SewerNetwork | 0.00325915 | 0.89 | 1.33434 | 0.141762 | 1.2 | 0 | Inspeksjonskum
f-va, SF, Bunnring | 0,0,0 | SF | 1000 | Betong | 2.37 | Betong | WS_StormwaterPipeNetwork | 0.530629 | 1.87 | 3.70499 | 0.307983 | 0.3 | 1000 | Inntak
f-va, S2, Bunnring | 0,255,0 | S2 | 425 | Plast | 1.06096 | Plast | WS_SewerNetwork | 0.00351532 | 0.959956 | 1.33434 | 0.141762 | 1.83904 | 0 | Inspeksjonskum
f-va, HS, Bunnring | 0,255,0 | HS | 400 | Plast | 0.66 | Plast | WS_SewerNetwork | 0.014509 | 0.66 | 1.25584 | 0.0238601 | 1.76 | -1179 | Inspeksjonskum
f-va, S, Bunnring | 0,255,0 | S | 400 | Plast | 0.660333 | Plast | WS_SewerNetwork | 0.0145163 | 0.660333 | 1.25584 | 0.0238601 | 1.76 | -1179 | Inspeksjonskum
